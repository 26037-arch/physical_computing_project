// ====================================================================
// 아두이노 큐브 풀이 로봇 V5H — 제출용 단일 스케치
// 팀: 1반 6팀 (1103 김재혁 · 1105 나준우)    컴퓨터과학2 피지컬 컴퓨팅 수행평가
// 보드: Arduino UNO R4 WiFi (UNO R3 호환 — 헤더 핀 배치 동일)
// 필요 라이브러리: Servo (내장), Wire (내장), LiquidCrystal I2C (LiquidCrystal_I2C.h, 라이브러리 관리자에서 설치)
// 사용법: Arduino IDE 에서 이 파일 하나만 열어 그대로 컴파일·업로드한다 (파일 하나로 합친 것이며 로직은 원본과 같다).
//
// 합치기 전 원본 파일 (v5/firmware/main/) — 이 파일 안에서 아래 순서로 이어 붙였다:
//   tables.h       자동 생성 표(이동 순열, 크로스·F2L 거리표, OLL/PLL 공식 조회표)
//   cube.h         큐브 상태 모델 선언 (코너·에지 순열/방향, 18수)
//   solver.h       CFOP 풀이기 선언 (크로스·F2L IDA*, OLL·PLL 조회)
//   motors.h       A4988 스텝 모터(컵) 핀·마이크로스텝·가속 상수와 Motors 선언
//   mechanism.h    기구 절차 선언 (후드 서보·리프터 서보, 스핀·뒤집기·층 회전)
//   cube.cpp       큐브 상태 모델 구현 (수 적용, 54 스티커 출력, 섞기 수열·수열 파싱)
//   solver.cpp     풀이기 구현 (크로스 IDA*, F2L 트리거 매크로 IDA*, OLL/PLL 표 조회)
//   motors.cpp     스텝 모터 구동 구현 (등가속 사다리꼴 램프)
//   mechanism.cpp  기구 절차 구현 (장착·배출, 후드, 스핀, 뒤집기, 재배향)
//   main.ino       setup/loop, 시리얼 명령 처리, 버튼(짧게/길게), LCD, 부저
//
// 버튼 사용법 (A2 버튼 1개): 짧게 누름 = START (풀린 상태면 섞기, 아니면 풀기),
//                           1.2 s 이상 길게 누름 = LOAD (장착 / 장착 중이면 배출).
//
// 시리얼(115200) 접점 규칙 — 모든 명령은 한 줄, 수열은 "R U R' U2" 표기:
//   S [seed]   섞기 (seed 생략 시 micros 기반). 출력: SCRAMBLE seed=<n> (20): <수열>
//   V          풀기. 단계마다 "<이름> (<수>): <수열> | nodes=.. ms=.." 출력 후 TOTAL, 실행, SOLVED ok=1
//   M <수열>   임의 수열 실행 (PC 시뮬레이터·스마트큐브 입력용)
//   L / E      장착 한 단계(LOAD 버튼과 같음) / 배출
//   F / Y <k>  시연용 뒤집기 / 스핀 y^k (k 1..3)
//   P          현재 상태 54 스티커 출력 (STATE URRF...) + MECH 상태      R  모델을 풀린 상태로 리셋
//   Q 0|1      가상 모드(1=모터·서보 생략, 절차는 출력)
//   H c o l    후드 서보 각 CLOSE/OPEN/LOAD 조정 (기본 15 75 135, 지금 자세에 바로 적용)   K <각> 리프터 최상 각 (기본 180)
//   O <o> [p]  층 회전 오버슈트 o 스텝 (기본 12 = 5.4°) / 컵 한쪽 여유 p 스텝 (기본 5 = 2.25°, 0 = 중심 맞춤 끔). 1 스텝 = 0.45°
//   J <±n>     컵을 n 스텝 미세 회전(+ = 위에서 봐서 시계). 큐브 모델·자세는 그대로 — 전원을 켠 뒤 컵 영점(노치가 정확히 뒤)을 맞출 때
// ====================================================================

#include <Arduino.h>
#include <stdint.h>
#include <avr/pgmspace.h>  // AVR: 플래시 접근, UNO R4(Renesas): 호환 매크로
#include <Servo.h>
#include <Wire.h>
#include <LiquidCrystal_I2C.h>

// ===== 원본: tables.h =====
// 자동 생성 파일 — 수정하지 말 것. 생성: node tools/gen_tables.js (2026-10-23)
// 큐브 치환표, IDA* 가지치기 거리표, OLL/PLL 인식 키와 공식 수열. 모두 PROGMEM(플래시)에 둔다.
//
// [수학적 정의 — docs/MATH.md]
//  MOVE_*[m]        : 수 M_m = (σ^M, o^M).  적용: σ'(i) = σ(σ^M(i)), o'(i) = o(σ^M(i)) + o^M(i)
//  EDGE_TO/DO[m][p] : 조각 상태 전이 T_M(p,o) = (q, o + o^M(q)), q = (σ^M)^-1(p)   (코너도 동일)
//  CROSS_PAIR[..]   : 조각 집합 P 의 사영 그래프에서 목표까지 BFS 거리 d_P(u). 실제 L수 해의 사영 경로도 길이 L
//                     이므로 d_P(π_P(s)) ≤ d*(s) — 허용적 휴리스틱 (18수 기준).
//  F2L_PAIR[s][..]  : 슬롯 s 의 코너·엣지 쌍이 매크로 수(U^k 비용 1, 트리거 X U^k X' 비용 3)로 풀리기까지의 최단 겉면 수.
//                     트리거는 크로스·다른 슬롯을 보존하므로 F2L 탐색은 쌍 2바이트만 추적한다. 255 = 도달 불가(크로스 자리).
//  F2L_TRIG[s][fam] : 슬롯 s 트리거의 첫 수 X (fam 0: a U^k a', fam 1: b' U^k b). 마지막 수는 X 의 역수.
//  OLL_KEY[i]       : key_OLL(I·A_i^-1) — 공식 A_i 의 역연산을 풀린 큐브에 적용한 상태의 방향 키.
//                     s·r·A 가 방향 0 ⇔ key_OLL(s·r) = OLL_KEY  (방향은 위치와 무관한 아핀 함수로 변하므로)
//  PLL_KEY[i]       : key_PLL(I·u^-1·A^-1), PLL_AUF[i] = u.   s·r·A·u = I ⇔ s·r = u^-1·A^-1
//  공식 수열은 wide/슬라이스/회전을 겉면 6면 수로 변환한 것: ρ X = X^ρ ρ 로 회전을 오른쪽으로 밀어 S = S'·ρ_net,
//                     풀린 상태는 회전 불변이므로 s·S = I ⇔ s·S' = I.  (sim/cube.js expandAlg)
//  생성 시 OLL 216 상태·PLL 288 상태 전부에 대해 "조회됨 ∧ 적용 후 목표 달성" 을, F2L 은 완성 슬롯 조합 8가지 × 쌍 상태 전부가
//  허용 매크로만으로 풀리는지를 검사한다.

static const uint8_t MOVE_CP[18][8] PROGMEM = {
  3,0,1,2,4,5,6,7,
  2,3,0,1,4,5,6,7,
  1,2,3,0,4,5,6,7,
  4,1,2,0,7,5,6,3,
  7,1,2,4,3,5,6,0,
  3,1,2,7,0,5,6,4,
  1,5,2,3,0,4,6,7,
  5,4,2,3,1,0,6,7,
  4,0,2,3,5,1,6,7,
  0,1,2,3,5,6,7,4,
  0,1,2,3,6,7,4,5,
  0,1,2,3,7,4,5,6,
  0,2,6,3,4,1,5,7,
  0,6,5,3,4,2,1,7,
  0,5,1,3,4,6,2,7,
  0,1,3,7,4,5,2,6,
  0,1,7,6,4,5,3,2,
  0,1,6,2,4,5,7,3
};
static const uint8_t MOVE_CO[18][8] PROGMEM = {
  0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,
  2,0,0,1,1,0,0,2,
  0,0,0,0,0,0,0,0,
  2,0,0,1,1,0,0,2,
  1,2,0,0,2,1,0,0,
  0,0,0,0,0,0,0,0,
  1,2,0,0,2,1,0,0,
  0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,
  0,1,2,0,0,2,1,0,
  0,0,0,0,0,0,0,0,
  0,1,2,0,0,2,1,0,
  0,0,1,2,0,0,2,1,
  0,0,0,0,0,0,0,0,
  0,0,1,2,0,0,2,1
};
static const uint8_t MOVE_EP[18][12] PROGMEM = {
  3,0,1,2,4,5,6,7,8,9,10,11,
  2,3,0,1,4,5,6,7,8,9,10,11,
  1,2,3,0,4,5,6,7,8,9,10,11,
  8,1,2,3,11,5,6,7,4,9,10,0,
  4,1,2,3,0,5,6,7,11,9,10,8,
  11,1,2,3,8,5,6,7,0,9,10,4,
  0,9,2,3,4,8,6,7,1,5,10,11,
  0,5,2,3,4,1,6,7,9,8,10,11,
  0,8,2,3,4,9,6,7,5,1,10,11,
  0,1,2,3,5,6,7,4,8,9,10,11,
  0,1,2,3,6,7,4,5,8,9,10,11,
  0,1,2,3,7,4,5,6,8,9,10,11,
  0,1,10,3,4,5,9,7,8,2,6,11,
  0,1,6,3,4,5,2,7,8,10,9,11,
  0,1,9,3,4,5,10,7,8,6,2,11,
  0,1,2,11,4,5,6,10,8,9,3,7,
  0,1,2,7,4,5,6,3,8,9,11,10,
  0,1,2,10,4,5,6,11,8,9,7,3
};
static const uint8_t MOVE_EO[18][12] PROGMEM = {
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,1,0,0,0,1,0,0,1,1,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,1,0,0,0,1,0,0,1,1,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,1,0,0,0,1,0,0,1,1,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,1,0,0,0,1,0,0,1,1
};

// 조각 이동표: 위치 p 의 조각은 수 m 뒤 EDGE_TO[m][p] 로 가고 방향에 EDGE_DO[m][p] 가 더해진다 (탐색 중 조각 추적용)
static const uint8_t EDGE_TO[18][12] PROGMEM = {
  1,2,3,0,4,5,6,7,8,9,10,11,
  2,3,0,1,4,5,6,7,8,9,10,11,
  3,0,1,2,4,5,6,7,8,9,10,11,
  11,1,2,3,8,5,6,7,0,9,10,4,
  4,1,2,3,0,5,6,7,11,9,10,8,
  8,1,2,3,11,5,6,7,4,9,10,0,
  0,8,2,3,4,9,6,7,5,1,10,11,
  0,5,2,3,4,1,6,7,9,8,10,11,
  0,9,2,3,4,8,6,7,1,5,10,11,
  0,1,2,3,7,4,5,6,8,9,10,11,
  0,1,2,3,6,7,4,5,8,9,10,11,
  0,1,2,3,5,6,7,4,8,9,10,11,
  0,1,9,3,4,5,10,7,8,6,2,11,
  0,1,6,3,4,5,2,7,8,10,9,11,
  0,1,10,3,4,5,9,7,8,2,6,11,
  0,1,2,10,4,5,6,11,8,9,7,3,
  0,1,2,7,4,5,6,3,8,9,11,10,
  0,1,2,11,4,5,6,10,8,9,3,7
};
static const uint8_t EDGE_DO[18][12] PROGMEM = {
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,1,0,0,0,1,0,0,1,1,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,1,0,0,0,1,0,0,1,1,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,1,0,0,0,1,0,0,1,1,
  0,0,0,0,0,0,0,0,0,0,0,0,
  0,0,0,1,0,0,0,1,0,0,1,1
};
static const uint8_t CORNER_TO[18][8] PROGMEM = {
  1,2,3,0,4,5,6,7,
  2,3,0,1,4,5,6,7,
  3,0,1,2,4,5,6,7,
  3,1,2,7,0,5,6,4,
  7,1,2,4,3,5,6,0,
  4,1,2,0,7,5,6,3,
  4,0,2,3,5,1,6,7,
  5,4,2,3,1,0,6,7,
  1,5,2,3,0,4,6,7,
  0,1,2,3,7,4,5,6,
  0,1,2,3,6,7,4,5,
  0,1,2,3,5,6,7,4,
  0,5,1,3,4,6,2,7,
  0,6,5,3,4,2,1,7,
  0,2,6,3,4,1,5,7,
  0,1,6,2,4,5,7,3,
  0,1,7,6,4,5,3,2,
  0,1,3,7,4,5,2,6
};
static const uint8_t CORNER_DO[18][8] PROGMEM = {
  0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,
  1,0,0,2,2,0,0,1,
  0,0,0,0,0,0,0,0,
  1,0,0,2,2,0,0,1,
  2,1,0,0,1,2,0,0,
  0,0,0,0,0,0,0,0,
  2,1,0,0,1,2,0,0,
  0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,
  0,0,0,0,0,0,0,0,
  0,2,1,0,0,1,2,0,
  0,0,0,0,0,0,0,0,
  0,2,1,0,0,1,2,0,
  0,0,2,1,0,0,1,2,
  0,0,0,0,0,0,0,0,
  0,0,2,1,0,0,1,2
};

// 조각 1개 거리표: [조각][위치*방향수+방향]. _18 = 18수, _15 = D 제외 15수(F2L)
static const uint8_t EDGE1_18[12][24] PROGMEM = {
  0,3,1,2,1,3,1,2,1,3,2,2,2,3,2,2,1,2,2,2,2,2,1,2,
  1,2,0,3,1,2,1,3,2,2,1,3,2,2,2,3,2,1,2,1,2,2,2,2,
  1,3,1,2,0,3,1,2,2,3,2,2,1,3,2,2,2,2,1,2,1,2,2,2,
  1,2,1,3,1,2,0,3,2,2,2,3,2,2,1,3,2,2,2,2,2,1,2,1,
  1,3,2,2,2,3,2,2,0,3,1,2,1,3,1,2,1,2,2,2,2,2,1,2,
  2,2,1,3,2,2,2,3,1,2,0,3,1,2,1,3,2,1,2,1,2,2,2,2,
  2,3,2,2,1,3,2,2,1,3,1,2,0,3,1,2,2,2,1,2,1,2,2,2,
  2,2,2,3,2,2,1,3,1,2,1,3,1,2,0,3,2,2,2,2,2,1,2,1,
  1,2,2,1,2,2,2,2,1,2,2,1,2,2,2,2,0,3,1,3,2,3,1,3,
  2,2,2,1,1,2,2,2,2,2,2,1,1,2,2,2,1,3,0,3,1,3,2,3,
  2,2,2,2,1,2,2,1,2,2,2,2,1,2,2,1,2,3,1,3,0,3,1,3,
  1,2,2,2,2,2,2,1,1,2,2,2,2,2,2,1,1,3,2,3,1,3,0,3
};
static const uint8_t EDGE1_15[12][24] PROGMEM = {
  0,3,1,2,1,3,1,2,1,3,2,2,2,3,2,2,1,2,2,2,2,2,1,2,
  1,2,0,3,1,2,1,3,2,2,1,3,2,2,2,3,2,1,2,1,2,2,2,2,
  1,3,1,2,0,3,1,2,2,3,2,2,1,3,2,2,2,2,1,2,1,2,2,2,
  1,2,1,3,1,2,0,3,2,2,2,3,2,2,1,3,2,2,2,2,2,1,2,1,
  1,3,2,2,2,3,2,2,0,4,3,2,3,4,3,2,1,3,2,3,2,3,1,3,
  2,2,1,3,2,2,2,3,3,2,0,4,3,2,3,4,3,1,3,1,3,2,3,2,
  2,3,2,2,1,3,2,2,3,4,3,2,0,4,3,2,2,3,1,3,1,3,2,3,
  2,2,2,3,2,2,1,3,3,2,3,4,3,2,0,4,3,2,3,2,3,1,3,1,
  1,2,2,1,2,2,2,2,1,3,3,1,2,3,3,2,0,3,1,3,2,3,1,3,
  2,2,2,1,1,2,2,2,2,3,3,1,1,3,3,2,1,3,0,3,1,3,2,3,
  2,2,2,2,1,2,2,1,2,3,3,2,1,3,3,1,2,3,1,3,0,3,1,3,
  1,2,2,2,2,2,2,1,1,3,3,2,2,3,3,1,1,3,2,3,1,3,0,3
};
static const uint8_t CORNER1_15[8][24] PROGMEM = {
  0,2,2,1,2,1,1,2,2,1,1,2,2,1,1,1,2,2,2,2,2,1,2,2,
  1,1,2,0,2,2,1,2,1,1,2,2,1,2,2,2,1,1,1,2,2,2,2,2,
  1,2,2,1,1,2,0,2,2,1,2,1,2,2,2,1,2,2,2,1,1,1,2,2,
  1,2,1,1,2,2,1,1,2,0,2,2,1,2,2,2,2,2,1,2,2,2,1,1,
  2,1,1,1,2,2,2,2,2,1,2,2,0,2,2,3,1,2,2,2,2,3,2,1,
  1,2,2,2,1,1,1,2,2,2,2,2,3,2,1,0,2,2,3,1,2,2,2,2,
  2,2,2,1,2,2,2,1,1,1,2,2,2,2,2,3,2,1,0,2,2,3,1,2,
  1,2,2,2,2,2,1,2,2,2,1,1,3,1,2,2,2,2,3,2,1,0,2,2
};

// 크로스 엣지 쌍 거리표 (18수): CROSS_PAIRS 순서, 인덱스 = 상태A*24+상태B
static const uint8_t CROSS_PAIRS[6][2] PROGMEM = {
  4,5,
  4,6,
  4,7,
  5,6,
  5,7,
  6,7
};
static const uint8_t CROSS_PAIR[6][576] PROGMEM = {
  0,0,2,4,3,3,3,4,2,3,1,4,2,3,2,4,3,2,3,2,3,3,3,2,
  0,0,4,5,4,5,5,4,4,4,3,4,3,5,4,4,4,3,4,4,4,4,3,4,
  4,4,0,0,3,4,4,4,3,4,2,4,2,4,3,4,3,3,3,3,3,4,4,3,
  4,3,0,0,4,4,4,4,3,3,3,4,3,4,3,4,4,2,4,3,4,4,4,3,
  4,4,3,5,0,0,3,5,3,4,2,5,3,4,2,5,4,3,4,3,4,3,4,3,
  4,4,4,4,0,0,5,5,3,4,3,4,4,4,4,4,4,3,3,4,4,4,4,4,
  3,4,3,4,4,4,0,0,2,4,2,4,3,4,3,4,3,3,4,3,3,4,3,3,
  4,4,3,5,4,4,0,0,3,3,2,4,3,4,3,4,4,3,4,3,4,3,4,3,
  2,3,1,3,2,2,2,3,0,0,0,4,3,2,3,4,3,1,3,1,3,2,3,3,
  4,4,4,4,4,4,5,4,0,0,4,4,3,4,4,5,3,4,4,3,4,4,4,4,
  3,3,2,4,2,3,3,3,4,3,0,0,1,3,4,3,3,2,2,2,2,3,3,3,
  4,3,3,4,4,3,4,4,3,4,0,0,3,3,3,5,4,3,4,2,4,3,4,4,
  3,3,2,4,3,3,2,4,4,3,3,4,0,0,1,4,3,2,3,2,3,2,3,2,
  4,4,4,4,4,4,5,4,3,5,4,5,0,0,4,4,4,4,4,3,3,4,4,4,
  2,3,2,3,3,3,3,4,1,3,3,3,4,3,0,0,2,2,3,2,3,3,2,3,
  4,4,3,5,4,4,4,4,3,3,2,4,3,4,0,0,4,3,4,3,4,3,4,3,
  3,2,2,3,3,3,3,3,2,3,1,4,2,3,2,4,0,0,3,2,3,3,3,3,
  3,4,3,4,3,4,4,4,3,4,3,3,2,4,3,4,0,0,3,3,3,4,4,4,
  3,3,2,4,3,3,3,4,3,4,3,4,3,3,2,4,4,3,0,0,4,3,4,3,
  4,4,3,3,3,4,4,4,3,4,3,4,2,4,3,4,4,3,0,0,3,4,4,4,
  4,4,3,4,4,3,3,4,3,3,2,4,3,3,2,4,4,3,4,3,0,0,4,3,
  3,4,3,4,3,4,4,4,2,4,3,4,3,4,3,3,3,3,4,3,0,0,3,4,
  3,3,2,4,3,3,3,4,2,2,1,3,2,3,2,3,3,2,3,2,3,3,0,0,
  3,4,3,4,4,4,4,3,2,4,3,4,3,4,3,4,3,3,4,3,4,4,0,0,
  0,0,3,3,2,4,3,3,2,4,2,3,1,4,2,3,3,3,2,3,2,3,3,3,
  0,0,4,5,4,5,4,5,4,4,3,4,3,5,3,4,4,4,4,4,4,4,4,4,
  4,4,0,0,3,4,3,4,3,4,3,4,2,4,2,4,3,4,3,4,3,3,4,3,
  4,4,0,0,3,5,4,4,3,4,3,3,2,4,3,4,4,3,3,4,3,4,4,4,
  3,5,4,4,0,0,4,4,2,5,3,4,2,5,3,4,3,4,3,4,3,4,3,4,
  5,5,4,4,0,0,4,4,4,5,3,4,3,4,3,4,5,4,4,4,4,4,5,4,
  4,4,3,4,3,4,0,0,3,4,2,4,2,4,3,4,4,3,3,3,3,4,3,4,
  4,4,4,4,3,5,0,0,3,4,3,4,2,4,3,3,4,4,3,4,3,4,4,3,
  2,3,2,2,1,3,2,2,0,0,3,2,0,4,3,2,2,3,1,3,1,3,2,3,
  5,4,4,4,4,5,4,4,0,0,3,4,4,5,3,4,4,4,4,4,4,4,4,4,
  3,3,3,3,2,3,2,3,4,3,0,0,3,3,1,3,3,3,2,3,2,2,3,2,
  4,4,4,3,3,4,4,4,3,5,0,0,2,4,3,4,4,4,3,3,3,4,4,4,
  2,4,3,3,2,4,3,3,1,4,4,3,0,0,4,3,2,3,2,3,2,3,2,3,
  5,5,4,4,4,4,4,4,4,5,3,5,0,0,3,5,5,4,4,4,4,4,5,4,
  3,3,2,3,2,3,3,3,4,3,1,3,3,3,0,0,3,2,2,2,2,3,3,3,
  4,4,4,4,3,4,4,3,3,5,3,4,2,4,0,0,4,4,3,4,3,3,4,4,
  3,4,3,3,2,4,3,3,2,4,2,3,1,4,2,3,0,0,2,4,2,3,3,3,
  4,4,4,4,3,4,3,4,3,4,3,3,3,4,2,4,0,0,4,4,3,3,4,3,
  3,5,3,4,3,4,4,4,2,5,3,4,2,4,3,4,3,4,0,0,3,4,3,4,
  4,4,4,3,3,4,3,4,3,4,3,4,3,4,2,4,4,4,0,0,3,3,4,3,
  3,5,4,4,3,4,3,4,2,5,3,4,2,4,3,4,3,4,3,4,0,0,3,4,
  4,4,3,4,3,4,4,3,3,4,2,4,3,4,3,4,4,3,3,3,0,0,4,4,
  3,4,3,3,2,4,3,3,2,4,2,3,1,4,2,3,3,3,2,3,2,4,0,0,
  4,4,3,4,3,4,4,4,3,4,2,4,3,4,3,3,4,3,3,3,4,4,0,0,
  0,0,3,4,3,3,2,4,2,3,2,4,2,3,1,4,3,2,3,3,3,2,3,2,
  0,0,5,4,4,5,4,5,4,4,4,4,3,5,3,4,3,4,4,4,4,4,4,3,
  3,4,0,0,4,4,3,4,2,4,3,4,3,4,2,4,3,3,3,4,4,3,3,3,
  4,4,0,0,4,4,3,5,3,3,3,4,3,4,2,4,4,3,4,3,4,3,4,3,
  4,4,3,5,0,0,3,5,3,4,2,5,3,4,2,5,4,3,4,3,4,3,4,3,
  4,4,5,5,0,0,4,4,3,4,4,4,4,4,3,4,4,4,4,4,3,4,4,3,
  4,4,4,4,3,4,0,0,3,4,3,4,2,4,2,4,4,3,3,4,3,3,3,3,
  4,3,4,4,4,4,0,0,3,3,3,4,3,4,3,4,4,3,4,4,4,3,4,2,
  2,3,2,3,2,2,1,3,0,0,3,4,3,2,0,4,3,3,3,2,3,1,3,1,
  4,4,5,4,4,4,4,4,0,0,4,5,3,4,4,4,4,4,4,4,4,3,3,4,
  2,3,3,4,3,3,2,3,1,3,0,0,4,3,3,3,2,3,3,3,3,2,2,2,
  4,4,4,4,4,4,3,5,3,3,0,0,3,4,2,4,4,3,4,3,4,3,4,3,
  3,3,2,4,3,3,2,4,4,3,1,4,0,0,3,4,3,2,3,2,3,2,3,2,
  4,4,5,4,4,4,4,4,3,5,4,4,0,0,4,5,4,4,3,4,4,3,4,4,
  3,3,3,3,2,3,2,4,4,3,4,3,1,3,0,0,3,3,2,3,2,2,3,2,
  4,3,4,4,4,3,3,4,3,4,3,5,3,3,0,0,4,4,4,3,4,2,4,3,
  3,3,3,4,3,3,2,4,2,2,2,3,2,3,1,3,0,0,3,3,3,2,3,2,
  3,4,4,3,4,4,3,4,2,4,3,4,3,4,3,4,0,0,4,4,4,3,3,3,
  4,4,3,4,4,3,3,4,3,3,2,4,3,3,2,4,4,3,0,0,4,3,4,3,
  3,4,4,4,3,4,3,4,2,4,3,3,3,4,3,4,3,4,0,0,4,3,3,3,
  3,3,3,4,3,3,2,4,3,4,2,4,3,3,3,4,4,3,4,3,0,0,4,3,
  4,4,4,4,3,4,3,3,3,4,3,4,2,4,3,4,4,4,3,4,0,0,4,3,
  3,2,3,3,3,3,2,3,2,3,2,4,2,3,1,4,3,3,3,3,3,2,0,0,
  3,4,4,4,3,4,3,4,3,4,3,4,2,4,3,3,4,4,3,4,3,3,0,0,
  0,0,3,4,3,4,4,4,3,4,2,4,2,4,3,4,3,3,3,3,3,4,4,3,
  0,0,4,4,3,5,4,4,3,4,3,3,2,4,3,4,3,4,3,4,3,4,3,4,
  3,4,0,0,2,4,3,3,2,4,2,3,1,4,2,3,2,3,2,3,2,3,3,3,
  5,4,0,0,4,5,4,5,4,4,4,4,3,4,3,5,4,3,3,4,4,4,4,4,
  4,4,4,4,0,0,3,4,3,4,3,4,2,4,2,4,3,4,3,3,3,3,4,3,
  4,4,4,3,0,0,4,4,3,4,3,3,3,4,3,4,3,4,2,4,3,4,4,4,
  3,5,4,4,3,5,0,0,2,5,3,4,2,5,3,4,3,4,3,4,3,4,3,4,
  5,5,4,4,4,4,0,0,4,4,3,4,3,4,4,4,4,4,3,4,4,3,4,4,
  3,4,2,3,2,3,3,3,0,0,1,3,3,3,4,3,3,2,2,2,2,3,3,3,
  4,4,4,4,3,5,4,4,0,0,3,3,2,4,3,4,3,4,3,4,3,4,3,4,
  2,3,2,3,1,3,2,2,3,4,0,0,0,4,3,2,3,3,1,3,1,3,2,3,
  5,4,4,4,4,4,4,4,4,5,0,0,4,4,3,4,4,4,4,3,3,4,4,4,
  3,3,3,3,2,4,2,3,4,3,4,3,0,0,1,3,3,3,2,3,2,2,3,2,
  4,4,4,3,3,4,4,3,3,5,3,4,0,0,3,3,4,4,3,4,2,4,3,4,
  2,4,3,3,2,4,3,3,1,4,4,3,3,4,0,0,2,3,2,3,2,3,2,3,
  5,4,4,4,4,4,4,4,4,4,3,5,4,5,0,0,4,4,4,4,3,4,4,3,
  4,3,3,4,3,4,4,4,3,4,2,4,3,4,3,4,0,0,3,3,3,4,4,4,
  3,4,3,3,2,4,3,3,2,3,2,2,1,3,2,3,0,0,2,3,2,3,3,3,
  4,4,3,4,3,4,3,4,3,4,3,4,3,3,2,4,4,4,0,0,3,3,4,3,
  3,3,3,2,2,3,3,3,2,4,2,3,1,4,2,3,3,3,0,0,2,3,3,3,
  4,4,4,4,3,3,3,4,3,4,3,4,3,4,2,4,4,4,3,4,0,0,4,3,
  3,4,3,3,2,4,3,3,2,4,3,4,3,4,3,3,3,4,3,4,0,0,3,4,
  4,4,3,4,3,4,3,4,3,3,2,4,3,4,3,4,4,3,3,3,3,4,0,0,
  3,4,4,4,3,4,4,3,2,4,3,3,2,4,3,3,3,4,3,4,3,4,0,0,
  0,0,4,4,3,4,3,4,3,4,3,4,2,4,2,4,4,3,3,4,3,3,4,3,
  0,0,4,4,4,4,3,5,3,3,3,4,3,4,2,4,3,4,4,4,4,3,4,3,
  3,3,0,0,3,3,2,4,2,3,2,4,2,3,1,4,3,3,3,3,3,2,3,2,
  4,5,0,0,4,5,4,5,3,4,4,4,3,4,3,5,4,4,4,4,4,4,4,4,
  3,4,4,4,0,0,3,4,2,4,3,4,3,4,2,4,3,4,4,3,4,3,3,3,
  4,4,4,4,0,0,3,5,3,4,3,4,3,3,2,4,4,4,3,4,4,3,4,3,
  4,4,3,5,4,4,0,0,3,4,2,5,3,4,2,5,4,3,4,3,4,3,4,3,
  4,4,5,5,4,4,0,0,3,4,4,5,3,4,3,4,4,5,4,5,4,4,4,4,
  3,3,3,3,2,3,2,3,0,0,4,3,1,3,3,3,3,3,2,3,2,2,3,2,
  4,3,4,4,4,4,3,4,0,0,3,5,3,4,2,4,4,4,4,4,4,3,3,3,
  2,2,2,3,2,2,1,3,3,2,0,0,3,2,0,4,3,2,3,2,3,1,3,1,
  4,4,5,4,4,4,4,5,3,4,0,0,3,4,4,5,4,4,4,4,4,4,4,4,
  2,3,3,3,3,3,2,3,1,3,4,3,0,0,3,3,2,3,3,3,3,2,2,2,
  4,4,4,4,4,3,3,4,3,4,3,5,0,0,2,4,4,4,4,4,3,3,4,3,
  3,3,2,4,3,3,2,4,4,3,1,4,4,3,0,0,3,2,3,2,3,2,3,2,
  4,4,5,5,4,4,4,4,3,5,4,5,3,5,0,0,4,5,4,5,4,4,4,4,
  4,4,4,4,3,4,3,4,3,3,3,4,2,4,3,4,0,0,3,4,3,3,4,4,
  3,3,3,4,3,3,2,4,2,3,2,4,2,3,1,4,0,0,3,3,3,2,4,2,
  3,4,4,4,4,4,3,4,2,4,3,4,3,3,3,4,3,4,0,0,4,4,3,3,
  3,3,3,4,3,3,2,4,2,3,2,4,2,3,1,4,3,3,0,0,4,2,3,2,
  3,4,4,4,4,3,3,4,2,4,3,4,3,4,3,4,3,4,4,4,0,0,3,3,
  4,4,3,5,3,4,3,4,3,4,2,5,3,4,2,4,4,3,4,3,0,0,4,3,
  4,3,4,4,3,4,3,4,3,4,3,4,2,4,3,4,4,4,3,4,3,3,0,0,
  3,4,3,5,4,4,3,4,3,4,2,5,3,4,2,4,4,3,4,3,4,3,0,0,
  0,0,3,5,4,4,3,5,3,4,2,5,3,4,2,5,4,3,4,3,4,3,4,3,
  0,0,5,5,4,4,4,4,4,4,4,4,3,4,3,4,4,4,4,4,4,3,3,4,
  4,4,0,0,3,4,3,4,3,4,3,4,2,4,2,4,3,4,3,3,3,3,4,3,
  4,4,0,0,4,4,3,5,3,4,3,4,3,3,2,4,4,3,4,3,4,3,4,3,
  3,3,3,4,0,0,2,4,2,3,2,4,2,3,1,4,3,3,3,2,3,2,3,2,
  4,5,5,4,0,0,4,5,3,5,4,4,4,4,3,4,4,4,3,4,4,3,4,4,
  3,4,4,4,4,4,0,0,2,4,3,4,3,4,2,4,3,4,4,3,3,3,3,3,
  4,4,4,4,4,3,0,0,3,4,3,4,3,3,3,4,4,4,4,3,4,2,4,3,
  3,3,2,4,3,3,2,4,0,0,1,4,4,3,3,4,3,2,3,2,3,2,3,2,
  4,4,5,4,4,4,4,4,0,0,4,4,3,5,4,5,3,4,4,4,4,4,4,3,
  3,3,3,4,2,3,2,3,4,3,0,0,1,3,3,3,3,3,2,3,2,2,3,2,
  4,4,4,4,4,4,3,5,3,4,0,0,3,3,2,4,4,3,4,3,4,3,4,3,
  2,2,2,3,2,3,1,3,3,2,3,4,0,0,0,4,3,2,3,3,3,1,3,1,
  4,4,5,4,4,4,4,4,3,4,4,5,0,0,4,4,4,4,4,4,3,4,4,3,
  2,3,3,3,3,3,2,4,1,3,4,3,4,3,0,0,2,3,3,3,3,2,2,2,
  4,3,4,4,4,3,3,4,3,3,3,5,3,4,0,0,4,3,4,4,4,3,4,2,
  4,3,3,4,4,4,3,4,3,3,2,4,3,3,2,4,0,0,4,3,4,3,4,3,
  3,4,4,4,3,4,3,4,3,4,3,3,2,4,3,4,0,0,3,4,3,3,4,3,
  3,3,3,4,3,3,2,4,2,3,2,3,2,2,1,3,3,3,0,0,3,2,3,2,
  4,4,4,3,3,4,3,4,3,4,3,4,2,4,3,4,4,4,0,0,3,3,4,3,
  3,3,3,3,3,2,2,3,2,3,2,4,2,3,1,4,3,3,3,3,0,0,3,2,
  3,4,4,4,3,4,3,4,2,4,3,4,3,4,3,3,3,4,4,4,0,0,3,3,
  3,3,3,4,3,3,2,4,3,3,2,4,3,4,3,4,4,3,4,3,4,3,0,0,
  3,4,4,4,4,4,3,3,2,4,3,4,3,4,3,4,3,4,4,4,4,3,0,0
};

// F2L 쌍 거리표 (매크로 수 기준 겉면 수, 255 = 도달 불가): 슬롯 s = (코너 4+s, 엣지 8+s), 인덱스 = 코너상태*24+엣지상태
static const uint8_t F2L_PAIR[4][576] PROGMEM = {
  7,9,9,7,6,7,7,6,255,255,255,255,255,255,255,255,10,6,7,9,9,7,7,9,
  6,7,6,4,6,7,3,7,255,255,255,255,255,255,255,255,8,8,7,6,7,6,6,7,
  4,6,7,6,7,3,7,6,255,255,255,255,255,255,255,255,8,8,6,7,7,6,7,6,
  7,6,7,9,9,6,7,6,255,255,255,255,255,255,255,255,9,6,6,9,9,7,7,9,
  4,7,7,7,7,4,6,7,255,255,255,255,255,255,255,255,7,7,7,7,7,7,7,8,
  6,7,3,7,7,7,6,4,255,255,255,255,255,255,255,255,7,8,7,8,6,7,6,7,
  6,6,6,6,7,9,9,7,255,255,255,255,255,255,255,255,10,7,7,9,9,6,7,9,
  7,6,4,6,7,6,7,3,255,255,255,255,255,255,255,255,8,7,7,6,7,7,7,7,
  6,4,6,7,3,7,6,7,255,255,255,255,255,255,255,255,8,7,7,7,7,7,7,6,
  9,7,6,7,6,7,6,9,255,255,255,255,255,255,255,255,9,6,7,9,9,7,6,9,
  7,3,7,6,4,6,7,7,255,255,255,255,255,255,255,255,7,8,6,7,6,7,7,8,
  7,7,7,4,7,6,4,7,255,255,255,255,255,255,255,255,7,7,7,8,7,7,7,7,
  8,7,7,8,8,7,7,8,255,255,255,255,255,255,255,255,0,10,9,9,9,9,9,9,
  6,7,7,7,7,7,7,6,255,255,255,255,255,255,255,255,10,9,9,9,9,9,10,9,
  7,7,7,6,6,7,7,7,255,255,255,255,255,255,255,255,10,9,10,9,9,9,9,9,
  6,8,7,7,7,8,7,7,255,255,255,255,255,255,255,255,10,9,9,6,9,9,9,9,
  7,7,6,7,7,6,7,7,255,255,255,255,255,255,255,255,9,9,10,9,9,9,9,9,
  7,7,7,7,8,6,7,7,255,255,255,255,255,255,255,255,9,9,9,10,9,10,9,9,
  7,6,6,7,7,6,6,7,255,255,255,255,255,255,255,255,9,9,9,9,7,9,9,9,
  7,6,7,7,6,7,7,7,255,255,255,255,255,255,255,255,9,9,9,9,9,9,9,9,
  7,7,6,7,7,7,7,6,255,255,255,255,255,255,255,255,9,9,9,9,9,9,9,9,
  7,7,8,6,7,7,8,7,255,255,255,255,255,255,255,255,10,9,9,9,9,9,9,6,
  7,7,7,7,7,7,6,8,255,255,255,255,255,255,255,255,9,9,9,9,9,10,9,10,
  7,6,7,7,7,7,6,7,255,255,255,255,255,255,255,255,9,9,9,9,9,9,10,9,
  9,6,7,9,7,6,7,6,255,255,255,255,255,255,255,255,6,9,9,6,7,9,9,7,
  7,7,3,7,6,7,6,4,255,255,255,255,255,255,255,255,7,8,7,8,6,7,6,7,
  7,4,7,7,4,7,6,7,255,255,255,255,255,255,255,255,7,7,7,7,7,8,7,7,
  6,7,9,7,7,9,7,6,255,255,255,255,255,255,255,255,7,9,10,6,7,9,9,7,
  7,3,7,6,4,6,7,6,255,255,255,255,255,255,255,255,6,7,8,8,7,6,7,6,
  6,7,6,4,6,7,3,7,255,255,255,255,255,255,255,255,7,6,8,8,6,7,7,6,
  6,7,6,7,9,7,6,9,255,255,255,255,255,255,255,255,7,9,9,6,6,9,9,7,
  7,6,7,4,7,7,4,7,255,255,255,255,255,255,255,255,7,8,7,7,7,7,7,7,
  4,6,7,6,7,3,7,7,255,255,255,255,255,255,255,255,6,7,7,8,7,8,6,7,
  7,9,6,6,6,6,9,7,255,255,255,255,255,255,255,255,7,9,10,7,7,9,9,6,
  3,7,6,7,6,4,6,7,255,255,255,255,255,255,255,255,7,7,8,7,7,6,7,7,
  7,6,4,6,7,6,7,3,255,255,255,255,255,255,255,255,7,6,8,7,7,7,7,7,
  7,8,7,7,6,8,7,7,255,255,255,255,255,255,255,255,9,6,10,9,9,9,9,9,
  8,6,7,7,7,7,7,7,255,255,255,255,255,255,255,255,9,10,9,9,9,9,9,10,
  7,6,6,7,7,7,7,7,255,255,255,255,255,255,255,255,10,9,9,9,9,9,9,9,
  8,7,7,8,8,7,7,8,255,255,255,255,255,255,255,255,9,9,0,10,9,9,9,9,
  6,7,7,6,7,7,7,7,255,255,255,255,255,255,255,255,10,9,10,9,9,9,9,9,
  7,7,7,7,6,7,7,6,255,255,255,255,255,255,255,255,9,9,10,9,10,9,9,9,
  7,7,8,6,7,7,8,7,255,255,255,255,255,255,255,255,9,9,10,9,9,6,9,9,
  7,7,7,7,7,6,6,7,255,255,255,255,255,255,255,255,9,9,9,9,10,9,9,9,
  7,7,7,7,7,7,6,8,255,255,255,255,255,255,255,255,9,9,9,9,9,10,9,10,
  7,6,6,7,7,6,6,7,255,255,255,255,255,255,255,255,9,9,9,9,9,9,7,9,
  7,7,6,7,7,7,7,6,255,255,255,255,255,255,255,255,9,9,9,9,9,9,9,9,
  6,7,7,7,7,6,7,7,255,255,255,255,255,255,255,255,9,9,9,9,9,9,9,9,
  7,9,9,7,6,6,6,6,255,255,255,255,255,255,255,255,9,6,7,9,10,7,7,9,
  7,6,7,3,7,6,4,6,255,255,255,255,255,255,255,255,7,7,7,7,8,7,7,6,
  3,7,6,7,6,4,6,7,255,255,255,255,255,255,255,255,7,7,7,6,8,7,7,7,
  6,7,6,9,9,7,6,7,255,255,255,255,255,255,255,255,9,7,6,9,9,6,7,9,
  4,6,7,7,7,3,7,6,255,255,255,255,255,255,255,255,6,7,7,8,7,8,6,7,
  7,6,4,7,7,7,7,4,255,255,255,255,255,255,255,255,7,7,7,7,7,7,7,8,
  6,7,7,6,7,9,9,7,255,255,255,255,255,255,255,255,9,7,7,9,10,6,7,9,
  6,7,3,7,6,7,6,4,255,255,255,255,255,255,255,255,7,6,6,7,8,8,7,6,
  7,3,7,6,4,6,7,6,255,255,255,255,255,255,255,255,7,6,7,6,8,8,6,7,
  9,6,7,6,7,6,7,9,255,255,255,255,255,255,255,255,9,7,7,9,9,6,6,9,
  7,4,6,7,4,7,7,7,255,255,255,255,255,255,255,255,7,7,7,8,7,7,7,7,
  7,7,6,4,6,7,3,7,255,255,255,255,255,255,255,255,6,7,6,7,7,8,7,8,
  7,6,6,7,7,6,6,7,255,255,255,255,255,255,255,255,7,9,9,9,9,9,9,9,
  6,7,7,7,7,6,7,7,255,255,255,255,255,255,255,255,9,9,9,9,9,9,9,9,
  7,7,7,6,7,7,6,7,255,255,255,255,255,255,255,255,9,9,9,9,9,9,9,9,
  7,7,8,7,7,7,8,6,255,255,255,255,255,255,255,255,9,9,9,6,10,9,9,9,
  7,7,6,8,7,7,7,7,255,255,255,255,255,255,255,255,9,10,9,10,9,9,9,9,
  7,7,6,7,7,6,7,7,255,255,255,255,255,255,255,255,9,9,10,9,9,9,9,9,
  8,7,7,8,8,7,7,8,255,255,255,255,255,255,255,255,9,9,9,9,0,10,9,9,
  7,7,7,6,6,7,7,7,255,255,255,255,255,255,255,255,9,9,10,9,10,9,9,9,
  6,7,7,7,7,7,7,6,255,255,255,255,255,255,255,255,9,9,9,9,10,9,10,9,
  7,8,7,7,6,8,7,7,255,255,255,255,255,255,255,255,9,9,9,9,10,9,9,6,
  7,6,7,7,7,7,6,7,255,255,255,255,255,255,255,255,9,9,9,9,9,9,10,9,
  8,6,7,7,7,7,7,7,255,255,255,255,255,255,255,255,9,10,9,9,9,9,9,10,
  9,7,6,9,6,7,6,7,255,255,255,255,255,255,255,255,6,9,9,7,7,9,9,6,
  7,7,4,7,7,6,7,4,255,255,255,255,255,255,255,255,7,7,7,7,7,8,7,7,
  7,3,7,7,4,6,7,6,255,255,255,255,255,255,255,255,7,8,6,7,6,7,7,8,
  6,6,9,7,7,9,6,6,255,255,255,255,255,255,255,255,7,9,9,6,7,9,10,7,
  6,4,6,7,3,7,6,7,255,255,255,255,255,255,255,255,7,6,7,7,7,7,8,7,
  7,6,7,3,7,6,4,6,255,255,255,255,255,255,255,255,7,7,7,7,7,6,8,7,
  7,6,7,6,9,6,7,9,255,255,255,255,255,255,255,255,7,9,9,7,6,9,9,6,
  6,7,6,4,7,7,3,7,255,255,255,255,255,255,255,255,6,7,6,7,7,8,7,8,
  4,7,6,7,7,4,7,7,255,255,255,255,255,255,255,255,7,8,7,7,7,7,7,7,
  7,9,7,6,6,7,9,7,255,255,255,255,255,255,255,255,7,9,9,7,7,9,10,6,
  4,6,7,6,7,3,7,6,255,255,255,255,255,255,255,255,7,6,7,6,6,7,8,8,
  6,7,3,7,6,7,6,4,255,255,255,255,255,255,255,255,6,7,7,6,7,6,8,8,
  7,7,8,7,7,7,8,6,255,255,255,255,255,255,255,255,9,6,9,9,9,9,10,9,
  7,6,6,7,7,7,7,7,255,255,255,255,255,255,255,255,10,9,9,9,9,9,9,9,
  7,7,6,8,7,7,7,7,255,255,255,255,255,255,255,255,9,10,9,10,9,9,9,9,
  7,6,6,7,7,6,6,7,255,255,255,255,255,255,255,255,9,9,7,9,9,9,9,9,
  7,7,7,6,7,7,6,7,255,255,255,255,255,255,255,255,9,9,9,9,9,9,9,9,
  7,6,7,7,6,7,7,7,255,255,255,255,255,255,255,255,9,9,9,9,9,9,9,9,
  6,8,7,7,7,8,7,7,255,255,255,255,255,255,255,255,9,9,9,9,9,6,10,9,
  7,7,7,7,8,6,7,7,255,255,255,255,255,255,255,255,9,9,9,10,9,10,9,9,
  7,7,7,7,7,6,6,7,255,255,255,255,255,255,255,255,9,9,9,9,10,9,9,9,
  8,7,7,8,8,7,7,8,255,255,255,255,255,255,255,255,9,9,9,9,9,9,0,10,
  7,7,7,7,6,7,7,6,255,255,255,255,255,255,255,255,9,9,9,9,10,9,10,9,
  6,7,7,6,7,7,7,7,255,255,255,255,255,255,255,255,10,9,9,9,9,9,10,9
};
// F2L 트리거 첫 수: [슬롯][종류] (FR: R U^k R', F' U^k F / FL: F U^k F', L' U^k L / BL: L U^k L', B' U^k B / BR: B U^k B', R' U^k R)
static const uint8_t F2L_TRIG[4][2] PROGMEM = {
  3,8,
  6,14,
  12,17,
  15,5
};

// OLL: 인식 키(코너 방향 4개 base3 <<4 | 엣지 방향 4비트), 공식 수열은 OLL_MOVES[OLL_OFF[i]..OLL_OFF[i+1])
#define OLL_COUNT 57
static const uint16_t OLL_KEY[57] PROGMEM = {815,1231,431,639,419,630,1004,601,220,1257,1260,627,997,213,421,629,319,1023,735,15,1120,1216,112,240,912,624,992,12,252,92,246,892,245,85,179,310,188,540,533,309,124,1017,342,476,341,474,710,1228,1222,1219,709,714,803,806,810,805,5};
static const uint16_t OLL_OFF[58] PROGMEM = {0,11,23,36,49,56,63,70,77,88,99,110,123,134,144,154,164,177,190,203,216,227,236,245,253,261,268,275,285,298,309,318,327,335,346,355,367,375,387,396,405,418,431,437,443,449,457,469,479,488,497,507,517,528,539,550,564,574};
static const uint8_t OLL_MOVES[574] PROGMEM = {3,1,4,6,3,8,1,5,6,3,8,6,3,0,5,2,8,15,0,12,2,14,17,15,0,12,2,14,17,2,6,3,0,5,2,8,15,0,12,2,14,17,0,6,3,0,5,2,8,14,16,3,15,5,15,12,12,7,5,8,3,8,14,12,6,5,6,3,7,14,14,17,3,17,5,16,12,3,0,5,2,5,6,4,0,5,2,8,3,0,5,0,5,6,3,8,3,1,5,12,6,5,6,5,9,3,11,3,7,14,6,3,0,5,2,8,0,6,3,0,5,2,8,6,0,3,2,4,8,3,0,3,2,5,5,6,3,0,5,8,3,6,2,8,14,17,12,5,2,3,0,14,15,12,12,6,14,3,0,5,2,12,8,14,3,0,5,0,5,6,3,8,1,5,6,3,8,12,6,5,6,3,7,13,17,3,17,5,16,12,3,14,15,3,15,5,17,5,12,5,6,3,8,12,6,5,8,4,13,15,3,17,5,17,5,12,3,1,5,2,3,0,5,2,3,2,5,3,1,4,2,4,2,4,1,3,4,11,3,1,5,9,3,1,3,12,6,5,8,14,6,3,8,8,12,6,5,8,14,6,3,3,1,5,2,3,2,5,3,0,5,0,3,1,5,12,6,5,8,14,3,0,3,2,5,3,0,5,2,3,2,5,8,2,6,3,0,5,6,5,6,4,2,5,2,3,0,5,7,5,2,6,0,3,2,5,8,3,12,0,8,2,14,0,12,6,14,3,0,5,2,5,6,3,8,3,0,4,2,5,6,3,0,3,2,8,3,1,4,6,3,8,3,1,5,14,2,12,2,14,0,12,0,12,8,14,6,6,5,8,3,0,3,2,5,3,0,5,0,3,2,5,2,5,6,3,8,12,8,14,2,12,0,6,2,14,5,6,3,0,5,2,8,0,3,3,0,5,0,3,1,5,6,3,0,5,2,8,5,2,3,2,5,1,3,6,3,0,5,2,8,8,2,14,0,12,6,6,0,3,2,5,8,6,3,0,5,2,8,5,2,5,6,3,8,0,3,5,2,5,6,3,8,5,6,3,8,0,3,6,3,0,5,2,3,0,5,2,8,12,8,13,15,13,6,13,17,12,14,15,13,8,13,17,13,6,14,6,0,3,2,5,0,3,2,5,8,3,0,5,0,3,2,15,2,17,5,14,17,3,17,5,15,3,17,5,16,12,12,6,5,6,3,8,5,6,3,7,14,3,1,4,2,3,2,5,1,6,3,8,12,6,14,0,3,2,5,0,3,2,5,12,8,14,3,0,5,2,5,12,6,3,8,14};
static const uint8_t OLL_NUM[57] PROGMEM = {1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57}; // 0 = 2look 보충

// PLL: 인식 키(코너 위치 4개 2비트씩 <<8 | 엣지 위치 4개 2비트씩), PLL_AUF = 공식 뒤 U 조정(0..3)
#define PLL_COUNT 87
static const uint16_t PLL_KEY[87] PROGMEM = {39963,57708,14001,19398,53787,10092,30897,36294,58395,14700,20145,37830,55353,11598,29331,34788,55437,11730,29223,34680,55410,11655,29400,34605,55476,11721,29214,34659,55521,11574,29259,34716,7089,27846,45339,50796,55512,11565,29298,34695,55371,11676,29409,34614,14739,20196,37689,58446,37779,58596,14649,20046,55326,11619,29364,34761,7755,25500,46305,51510,55443,11748,29241,34638,7047,27864,45357,50802,7011,27828,45513,50718,37848,58413,14706,20103,37662,58467,14772,20169,27705,45390,50835,7140,27756,45489,50886};
static const uint16_t PLL_OFF[88] PROGMEM = {0,9,18,27,36,45,54,63,72,88,104,120,136,154,172,190,208,223,238,253,268,283,298,313,328,343,358,373,388,403,418,433,448,459,470,481,492,502,512,522,532,546,560,574,588,609,630,651,672,689,706,723,740,756,772,788,804,818,832,846,860,874,888,902,916,927,938,949,960,971,982,993,1004,1018,1032,1046,1060,1077,1094,1111,1128,1142,1156,1170,1184,1184,1184,1184};
static const uint8_t PLL_MOVES[1184] PROGMEM = {5,6,5,16,3,8,5,16,4,5,6,5,16,3,8,5,16,4,5,6,5,16,3,8,5,16,4,5,6,5,16,3,8,5,16,4,4,16,3,6,5,16,3,8,3,4,16,3,6,5,16,3,8,3,4,16,3,6,5,16,3,8,3,4,16,3,6,5,16,3,8,3,3,17,5,6,3,15,5,8,3,15,5,6,3,17,5,8,3,17,5,6,3,15,5,8,3,15,5,6,3,17,5,8,3,17,5,6,3,15,5,8,3,15,5,6,3,17,5,8,3,17,5,6,3,15,5,8,3,15,5,6,3,17,5,8,5,2,8,3,0,5,2,5,6,4,2,5,2,3,0,5,0,3,5,2,8,3,0,5,2,5,6,4,2,5,2,3,0,5,0,3,5,2,8,3,0,5,2,5,6,4,2,5,2,3,0,5,0,3,5,2,8,3,0,5,2,5,6,4,2,5,2,3,0,5,0,3,4,0,5,0,5,2,3,2,4,2,9,5,0,3,11,4,0,5,0,5,2,3,2,4,2,9,5,0,3,11,4,0,5,0,5,2,3,2,4,2,9,5,0,3,11,4,0,5,0,5,2,3,2,4,2,9,5,0,3,11,5,2,3,0,11,4,0,5,0,3,2,3,2,4,9,5,2,3,0,11,4,0,5,0,3,2,3,2,4,9,5,2,3,0,11,4,0,5,0,3,2,3,2,4,9,5,2,3,0,11,4,0,5,0,3,2,3,2,4,9,4,2,3,2,3,0,5,0,4,0,11,3,2,5,9,4,2,3,2,3,0,5,0,4,0,11,3,2,5,9,4,2,3,2,3,0,5,0,4,0,11,3,2,5,9,4,2,3,2,3,0,5,0,4,0,11,3,2,5,9,3,0,5,2,9,4,2,3,2,5,0,5,0,4,11,3,0,5,2,9,4,2,3,2,5,0,5,0,4,11,3,0,5,2,9,4,2,3,2,5,0,5,0,4,11,3,0,5,2,9,4,2,3,2,5,0,5,0,4,11,4,13,9,4,13,1,4,13,9,4,13,4,13,9,4,13,1,4,13,9,4,13,4,13,9,4,13,1,4,13,9,4,13,4,13,9,4,13,1,4,13,9,4,13,4,9,3,11,3,7,14,0,12,7,4,9,3,11,3,7,14,0,12,7,4,9,3,11,3,7,14,0,12,7,4,9,3,11,3,7,14,0,12,7,3,0,5,8,3,0,5,2,5,6,4,2,5,2,3,0,5,8,3,0,5,2,5,6,4,2,5,2,3,0,5,8,3,0,5,2,5,6,4,2,5,2,3,0,5,8,3,0,5,2,5,6,4,2,5,2,3,0,5,0,3,0,5,8,3,0,5,2,5,6,4,2,5,1,3,2,5,3,0,5,0,3,0,5,8,3,0,5,2,5,6,4,2,5,1,3,2,5,3,0,5,0,3,0,5,8,3,0,5,2,5,6,4,2,5,1,3,2,5,3,0,5,0,3,0,5,8,3,0,5,2,5,6,4,2,5,1,3,2,5,5,0,3,2,5,8,2,6,3,0,5,6,5,8,3,2,3,5,0,3,2,5,8,2,6,3,0,5,6,5,8,3,2,3,5,0,3,2,5,8,2,6,3,0,5,6,5,8,3,2,3,5,0,3,2,5,8,2,6,3,0,5,6,5,8,3,2,3,3,2,5,2,3,0,3,9,5,2,3,11,5,1,5,2,3,2,5,2,3,0,3,9,5,2,3,11,5,1,5,2,3,2,5,2,3,0,3,9,5,2,3,11,5,1,5,2,3,2,5,2,3,0,3,9,5,2,3,11,5,1,5,2,5,1,3,1,5,6,3,0,5,2,5,8,4,2,5,1,3,1,5,6,3,0,5,2,5,8,4,2,5,1,3,1,5,6,3,0,5,2,5,8,4,2,5,1,3,1,5,6,3,0,5,2,5,8,4,2,3,0,5,2,5,6,4,2,5,2,3,0,5,8,3,0,5,2,5,6,4,2,5,2,3,0,5,8,3,0,5,2,5,6,4,2,5,2,3,0,5,8,3,0,5,2,5,6,4,2,5,2,3,0,5,8,3,2,3,0,3,0,3,2,5,2,4,3,2,3,0,3,0,3,2,5,2,4,3,2,3,0,3,0,3,2,5,2,4,3,2,3,0,3,0,3,2,5,2,4,4,0,3,0,5,2,5,2,5,0,5,4,0,3,0,5,2,5,2,5,0,5,4,0,3,0,5,2,5,2,5,0,5,4,0,3,0,5,2,5,2,5,0,5,5,0,5,2,17,5,16,2,17,0,17,3,15,3,5,0,5,2,17,5,16,2,17,0,17,3,15,3,5,0,5,2,17,5,16,2,17,0,17,3,15,3,5,0,5,2,17,5,16,2,17,0,17,3,15,3,6,3,2,5,2,3,0,5,8,3,0,5,2,5,6,3,8,6,3,2,5,2,3,0,5,8,3,0,5,2,5,6,3,8,6,3,2,5,2,3,0,5,8,3,0,5,2,5,6,3,8,6,3,2,5,2,3,0,5,8,3,0,5,2,5,6,3,8,5,12,6,4,13,15,4,13,6,5,12,10,4,13,5,12,6,4,13,15,4,13,6,5,12,10,4,13,5,12,6,4,13,15,4,13,6,5,12,10,4,13,5,12,6,4,13,15,4,13,6,5,12,10,4,13};
static const uint8_t PLL_AUF[87] PROGMEM = {0,1,2,3,0,1,2,3,0,1,2,3,0,1,2,3,0,1,2,3,0,1,2,3,0,1,2,3,0,1,2,3,0,1,2,3,0,1,2,3,0,1,2,3,0,1,2,3,0,1,2,3,0,1,2,3,0,1,2,3,0,1,2,3,0,1,2,3,0,1,2,3,0,1,2,3,0,1,2,3,0,1,2,3,1,2,3};
static const uint8_t PLL_NAME_IDX[87] PROGMEM = {0,0,0,0,1,1,1,1,2,2,2,2,3,3,3,3,4,4,4,4,5,5,5,5,6,6,6,6,7,7,7,7,8,8,8,8,9,9,9,9,10,10,10,10,11,11,11,11,12,12,12,12,13,13,13,13,14,14,14,14,15,15,15,15,16,16,16,16,17,17,17,17,18,18,18,18,19,19,19,19,20,20,20,20,21,21,21};
#define PLL_NAME_COUNT 22
static const char PLL_NAMES[22][10] PROGMEM = {"Aa","Ab","E","F","Ga","Gb","Gc","Gd","H","Ja","Jb","Na","Nb","Ra","Rb","T","Ua","Ub","V","Y","Z","AUF"};

// ===== 원본: cube.h =====
// cube.h — 3x3 큐브의 큐비(cubie) 모델과 회전 표기. sim/cube.js 와 같은 규약. (수학 정리: docs/MATH.md 1~2절)
//
// [상태] s = (σc, oc, σe, oe),  σc ∈ S8, oc ∈ Z3^8, σe ∈ S12, oe ∈ Z2^12
//   cp[i] = σc(i) : 위치 i 에 놓인 코너 조각 번호,  co[i] = oc(i) : 그 조각의 시계 방향 꼬임 (0,1,2)
//   ep[i] = σe(i), eo[i] = oe(i) : 엣지도 같음 (방향 0,1).  풀린 상태 = σ 항등, o = 0
//   물리적 제약: Σoc ≡ 0 (mod 3), Σoe ≡ 0 (mod 2), sgn σc = sgn σe
//   → 상태 수 8!·3^8·12!·2^12 / (3·2·2) ≈ 4.3×10^19
//
// [수] 한 수 M 도 같은 꼴 (σ^M, o^M). 상태 s 에 M 을 적용한 s·M 은
//   (s·M)σ(i) = σ(σ^M(i)),   (s·M)o(i) = o(σ^M(i)) + o^M(i)  (mod 3 / mod 2)
//   "수 뒤에 위치 i 로 오는 조각 = 원래 σ^M(i) 에 있던 조각, 방향 = 그 조각 방향 + M 이 더하는 꼬임".
//   이 곱은 결합적이라 18수가 루빅스 큐브 군을 생성한다. M^4 = id, M^-1 = M^3.
//   수 번호 m = 3f + (k-1).  f: U=0 R=1 F=2 D=3 L=4 B=5,  k=1 시계 90°, 2 180°, 3 반시계 90°
//   tables.h 의 MOVE_CP/CO/EP/EO[m] 가 σ^M, o^M (M_{3f+1} = M_{3f}^2, M_{3f+2} = M_{3f}^3 로 생성).

enum Face : uint8_t { FACE_U = 0, FACE_R, FACE_F, FACE_D, FACE_L, FACE_B };

struct Cube {
  uint8_t cp[8], co[8], ep[12], eo[12];

  Cube() { reset(); }
  void reset();
  void move(uint8_t m);                              // 한 수 적용
  void apply(const uint8_t* seq, uint8_t n);         // 수열 적용
  bool isSolved() const;
  uint8_t edgeState(uint8_t cubie) const;            // 위치*2 + 방향 (0..23)
  uint8_t cornerState(uint8_t cubie) const;          // 위치*3 + 방향 (0..23)
  void facelets(char* out54) const;                  // 54 스티커 문자 'URFDLB' (시뮬레이터 동기화용)
};

// ---- 표기 ----
void moveName(uint8_t m, char* out);                 // out 에 "U", "U2", "U'" (널 포함 3바이트)
void printSeq(Print& p, const uint8_t* seq, uint8_t n);
int8_t parseMove(const char* tok);                   // "R'" → 수 번호, 실패 -1
uint8_t parseSeq(const char* str, uint8_t* out, uint8_t maxN);
uint8_t simplifySeq(uint8_t* seq, uint8_t n);        // 같은 면 연속 합치기, 새 길이 반환
void scrambleSeq(uint32_t seed, uint8_t* out, uint8_t n); // xorshift32 섞기 (sim/cube.js 와 동일 수열)

// ===== 원본: solver.h =====
// solver.h — CFOP 4단계 풀이기 (sim/solver.js 와 같은 알고리즘·같은 순서 → 같은 풀이 문자열)
//   Cross : IDA* 18수, 휴리스틱 = 크로스 엣지 쌍 거리표 6개의 최댓값. 크로스 엣지 4개의 상태만 추적.
//   F2L   : 사람의 직관 F2L 처럼 매크로 수만 쓴다 — U 회전 3가지 + 트리거 X U^k X' (슬롯마다 2종류 × k 3가지).
//           트리거는 정의상 크로스와 다른 슬롯을 보존하므로 탐색 상태는 끼우는 쌍 (코너, 엣지) 2바이트뿐이고
//           F2L_PAIR 는 그 매크로 그래프의 정확한 최단 거리(겉면 수)다. 완성된 슬롯의 트리거는 금지.
//           쌍 선택은 그리디: 거리표 값이 작은 슬롯부터, 한계를 1씩 올리며 후보를 번갈아 본다.
//   OLL/PLL : 플래시의 인식 키 조회 (사전 AUF 4가지), PLL 은 공식 뒤 AUF 포함
//
// [수학적 근거 요약 — docs/MATH.md 3~7절]
//  사영   π_x(s) = (p, o) 는 등변: π_x(s·M) = T_M(π_x(s)),  T_M(p,o) = ((σ^M)^-1(p), o + o^M((σ^M)^-1(p)))
//          → 조각당 1바이트만 갱신해도 휴리스틱이 전체 상태로 계산한 것과 같다.
//  크로스 거리표 d_P(u) = 조각 집합 P 의 사영 그래프에서 목표까지의 BFS 거리. 실제 L수 해의 사영 경로도 길이 L 이므로
//          h_P(s) = d_P(π_P(s)) ≤ d*(s).  허용적 h 의 최댓값도 허용적: h = max_P h_P ≤ d*.
//  IDA*   f = g + h ≤ bound. 같은 면 연속 금지(X^a X^b = X^(a+b)), 반대면은 가환(UD = DU)이라 한 순서만 →
//          분기 18 → 평균 ≈ 13.3, bound +1 마다 비용 ≈ 13배. 허용적 h 이므로 처음 찾는 해가 (허용 수 집합 안에서) 최단.
//  F2L    켤레 X U^k X^-1 은 X 가 U층으로 올린 조각(슬롯 하나의 코너·엣지)과 U층만 바꾼다 → 크로스·다른 슬롯 보존.
//          매크로 그래프(간선 비용 1·3) 의 최단 거리를 표로 두면 h 가 정확해 탐색이 거의 직진한다 (한 쌍 수백 노드).
//  OLL    A 적용 후 방향 o'(i) = o(σ^A(i)) + o^A(i) 는 위치와 무관한 방향 벡터의 아핀 함수 →
//          s·r·A 가 방향 0  ⇔  key_OLL(s·r) = key_OLL(I·A^-1).  표에는 풀린 큐브에 A^-1 을 적용한 키를 저장.
//  PLL    s·r·A·u = I  ⇔  s·r = u^-1·A^-1.  표에는 (A, u) 마다 key_PLL(I·u^-1·A^-1) 저장 (21×4 + AUF 3 = 87).

#define SOL_MAX 128     // 전체 풀이 최대 수
#define STAGE_MAX 40    // 단계 하나의 최대 수

// 단계가 끝날 때마다 호출: 이름("CROSS","F2L FR","OLL 23","PLL Jb"), 수열, 탐색 노드 수, 소요 ms
typedef void (*StageCallback)(const char* name, const uint8_t* moves, uint8_t n, uint32_t nodes, uint32_t ms);

class Solver {
 public:
  uint32_t nodes = 0;
  // 성공하면 out[0..outLen) 에 전체 풀이(같은 면 연속 합침). 실패(비정상 상태)면 false
  bool solve(const Cube& start, uint8_t* out, uint8_t& outLen, StageCallback cb);

 private:
  // ---- Cross ----
  uint8_t path[16], pathLen = 0;    // IDA* 결과
  uint8_t crossA[6], crossB[6];
  uint8_t hCross(const uint8_t* es, uint8_t limit) const;
  bool childFits(const uint8_t* es, uint8_t* es2, uint8_t m, uint8_t limit, uint8_t& h) const;
  bool searchCross(const uint8_t* es, uint8_t g, uint8_t remaining, int8_t lastFace);
  bool idaCross(const uint8_t* es, uint8_t maxBound);
  // ---- F2L (매크로 수 27개: 0..2 = U U2 U', 3 + (slot*2+fam)*3 + k = 트리거 X U^(k+1) X') ----
  uint8_t mpath[12], mpathLen = 0;  // 매크로 번호열
  static uint8_t macroMoves(uint8_t i, uint8_t* out);           // 매크로의 겉면 수열, 길이(1 또는 3) 반환
  static uint8_t macroKind(uint8_t i);                           // 같은 종류(연속 금지) 판정용: U = 0xFF, 트리거 = slot*2+fam
  bool searchF2L(uint8_t cs, uint8_t es, uint8_t g, uint8_t depth, uint8_t bound, int8_t last, const uint8_t* table, uint8_t allowedMask);
  // ---- OLL / PLL ----
  bool lookupOLL(const Cube& c, uint8_t* out, uint8_t& n, char* name);
  bool lookupPLL(const Cube& c, uint8_t* out, uint8_t& n, char* name);
};

// ===== 원본: motors.h =====
// motors.h — V5 스텝모터 제어: 컵(홀더) 모터 1개(NEMA17 + A4988 직결). 후드 닫힘이면 아래 층, 열림이면 큐브 전체가 돈다.
//   A4988 은 1/4 마이크로스텝(MS2 → 5 V): 90° = STEPS_PER_QUARTER = 200 스텝, 1 스텝 = 0.45°.
//     풀스텝(1.8°)으로는 컵 여유(±2.05°)·전원 인가 때 로터가 튀는 양(최대 ±3.6°)을 보정할 수 없고 저속 공진이 크다.
//     MS2 를 꽂지 않은 풀스텝 배선이면 MICROSTEP 을 1 로 바꾼다(다른 상수는 따라 바뀐다).
//   등가속 램프(D. Austin 2005: c0 = 0.676·√(2/a), c_n = c_{n-1} − 2·c_{n-1}/(4n+1)): 가속도가 전 구간에서 같아
//     토크가 가장 작은 고속 구간에 부하가 몰리지 않는다(탈조 = 영구 위치 오차를 막는 첫 번째 수단 — 센서가 없다).
//     남은 스텝이 지금까지 가속한 스텝 수 이하가 되면 같은 곡선을 거꾸로 따라 감속한다. 90° 약 0.2 s, 180° 약 0.3 s.
//   컵·후드 여유를 흡수하는 오버슈트·중심 맞춤 왕복은 Mechanism 이 한다 (mechanism.h).
//   방향: CW_LEVEL 이면 컵이 위에서 봐서 시계 방향 (docs/HARDWARE_V5.md 3.2절). 실물 배선에 따라 한 줄로 반전.

class Motors {
 public:
  void begin();
  void rotate(uint16_t steps, bool cwFromAbove);   // 등가속 회전 후 바로 반환 — 정착 지연은 호출자가 준다 (가상 모드면 즉시 반환)
  void setEnabled(bool on) { enabled = on; }       // false 면 모터 신호 없이 즉시 반환 (가상 모드)
  bool isEnabled() const { return enabled; }
  void hold(bool on);                              // A4988 ENABLE (LOW = 켬). 끄면 로터가 풀려 컵 영점을 잃는다 — 운전 중에는 끄지 않는다
  uint16_t lastMoveMs = 0;                         // 마지막 회전 시간(ms)

 private:
  bool enabled = true;
  void pulse(uint16_t gapUs);
  void setDir(bool cw);
};

// 핀 배치 (diagram.json, docs/HARDWARE_V5.md 4절과 함께 바꿀 것) — UNO R3/R4 공통 헤더
static const uint8_t STEP_PIN = 2, DIR_PIN = 7, EN_PIN = 6;
static const uint8_t MICROSTEP = 4;                               // A4988 MS1/MS2/MS3 = L/H/L (1/4 스텝)
static const uint16_t STEPS_PER_QUARTER = 50 * MICROSTEP;         // 90°
static const uint16_t MAX_SPS = 500 * MICROSTEP;                  // 최고 속도 (스텝/s) = 150 rpm
static const uint32_t ACCEL_SPS2 = 5000UL * MICROSTEP;            // 가속도 (스텝/s²) = 157 rad/s² → 큐브+컵 관성 토크 약 0.013 N·m
static const uint16_t MIN_US = 1000000UL / MAX_SPS;               // 등속 구간 스텝 간격 500 µs
static const uint16_t START_US = (uint16_t)(676000.0 * sqrt(2.0 / ACCEL_SPS2));   // 첫 스텝 간격 c0 = 6760 µs (delayMicroseconds 한계 16383 안)
static const bool CW_LEVEL = HIGH;         // DIR 이 이 레벨이면 컵이 위에서 봐서 시계 방향

// ===== 원본: mechanism.h =====
// mechanism.h — V5 기구 절차 (docs/HARDWARE_V5.md 3절): 컵 스텝모터 1 + 후드 서보 + 리프터 서보.
//   규칙·동작 순서·출력 줄은 sim/mechanism.js 와 같다 (flips/spins 횟수까지 Wokwi 로 교차검증).
//   물리 위치: U(0) R(1) F(2) D(3) L(4) B(5). ori[p] = 그 물리 위치에 지금 있는 논리 면.
//   모든 층 회전은 아래(D 위치)에서만 한다. 논리 면 f 를 아래로 가져오는 재배향:
//     D: 없음 / F: FLIP / R: SPIN y → FLIP / L: SPIN y' → FLIP / B: SPIN y2 → FLIP / U: FLIP → FLIP
//   SPIN y = 큐브 전체가 위에서 봐서 시계 방향(U 와 같은 방향) = 컵 시계. FLIP = x' (F→D, D→B, B→U, U→F).
//   TURN D = 아래 층을 아래에서 봐서 시계 = 컵을 위에서 봐서 반시계.
//   여유 보정(센서가 없으므로 큐브를 매번 기하로 다시 가운데에 놓는다) — cupMove(steps, cw, over):
//     큐브는 컵 안에서 ±2.05°(기둥 여유 1.0), 위 두 층은 후드 안에서 ±3.1°(여유 1.5) 놀 수 있다. θc = playSteps, θh = 후드 여유.
//     ① steps+over 전진  ② over+play 후진  ③ play 전진.  스텝 합은 항상 steps 라 컵 위치 오차는 쌓이지 않는다.
//     TURN (over = overshootSteps ≈ θc+θh): ① 끝에 아래 층은 컵−θc, 위 두 층은 후드 벽 +θh → 상대 회전 ≈ 90°
//          (이상 모델 가정: 컵 영점이 맞고, 시작 때 층이 정렬돼 있고, over = θc+θh, 접촉이 단단하고 반복되며,
//           ② 에서 위 두 층이 아래 층을 따라온다. 기본값은 5.40 − 5.15 = 0.25° 남는다. 실물에서는 ② 때 층이 미끄러질 수 있다 → BUILD 4b 로 맞춘다)
//          ② 가 컵 여유 2θc 를 지난 뒤 큐브 전체를 θh 만큼 되끌어 후드 가운데로, ③ 이 컵을 큐브 가운데로 가져온다.
//     SPIN (over = play): ① 뒤 큐브는 컵 기준 ±θc 어디든 있을 수 있다(관성) → ② 가 앞선 쪽 기둥으로 밀어 정확히 90° 에, ③ 컵 복귀.
//     FLIP 뒤 (steps = 0, over = play): 착지한 큐브가 어느 쪽으로 틀어져 있어도 ①② 가 틀어짐(최대 ±2.05°)을 없앤다
//          → 닫히는 후드 벽과 큐브 모서리 사이 여유가 최악 0.5 mm 에서 약 1.3 mm 로 (가로 치우침 ±1.0 mm 은 남는다).
//     play = 0 이면 ①② 만 남아 기존(오버슈트 후 복귀) 동작과 같다.
//   스핀·뒤집기 앞에는 HOOD OPEN, 층 회전 앞에는 HOOD CLOSE 가 자동으로 들어간다(상태가 바뀔 때만 줄을 낸다).
//   가상 모드(Motors::isEnabled()==false)에서는 줄만 내고 서보·스텝은 생략한다.

enum HoodPos : uint8_t { HOOD_CLOSE = 0, HOOD_OPEN = 1, HOOD_LOAD = 2 };

class Mechanism {
 public:
  void begin(Motors* m);
  bool doMove(uint8_t logicalMove);     // 재배향(+HOOD CLOSE) → TURN. 실패(장착 안 됨)면 false
  bool flip();                          // 큐브 x' (후드 OPEN → 90° → 리프터 올렸다 내림 → 60° + 중심 맞춤)
  bool spin(uint8_t k);                 // 큐브 전체 y^k (k 1..3), 후드 OPEN
  bool load();                          // LOAD 버튼 한 단계 (비어 있음→후드 LOAD·큐브 대기 / 넣음→후드 OPEN·장착 / 장착됨→배출)
  bool eject();
  bool isLoaded() const { return loaded; }
  bool waitingForCube() const { return !loaded && hoodPos == HOOD_LOAD; }
  void resetCounters() { flips = 0; spins = 0; hoods = 0; }
  void printStatus(Print& p);
  void rehood();                        // H 로 바꾼 각을 지금 자세에 바로 적용 (조정용)
  uint8_t ori[6];
  uint16_t flips = 0, spins = 0, hoods = 0;
  // 조정값 (시리얼 H/K/O 명령으로 바꾸고 맞으면 아래 기본값을 고친다)
  uint8_t hoodDeg[3] = {15, 75, 135};   // CLOSE / OPEN / LOAD (후드 각 0/60/120 + 15)
  uint8_t hoodFlipDeg = 105;            // 뒤집는 동안 후드 (90 + 15: 팔이 리프터 크로스바 뒤로 비킨다)
  uint8_t liftUpDeg = 180;              // 리프터 최상 (크랭크 사점)
  uint8_t overshootSteps = 3 * MICROSTEP;          // 층 회전 오버슈트 = 컵 여유 + 후드 여유 (12 스텝 = 5.4° ≈ 2.05° + 3.1°)
  uint8_t playSteps = (5 * MICROSTEP + 2) / 4;     // 컵 한쪽 여유 (5 스텝 = 2.25° ≈ 2.05°). 0 이면 중심 맞춤 생략

 private:
  Motors* motors = nullptr;
  Servo hood, lift;
  uint8_t hoodPos = HOOD_OPEN;
  uint8_t hoodNow = 0;                  // 후드 서보에 마지막으로 쓴 각 (가상 모드에서는 바뀌지 않는다)
  bool loaded = false;
  bool virt() const { return !motors->isEnabled(); }
  bool ready();                         // 장착돼 있거나 가상 모드면 true, 아니면 "ERR not loaded"
  void setHood(uint8_t pos);
  void hoodTo(uint8_t deg, uint16_t ms);
  void cupMove(uint16_t steps, bool cw, uint8_t over);
  void sweep(Servo& s, uint8_t from, uint8_t to, uint16_t ms);
  void resetOri();
};

// 핀 배치 (diagram.json, docs/HARDWARE_V5.md 4절) — UNO R3/R4 공통 헤더
static const uint8_t HOOD_SERVO_PIN = 8, LIFT_SERVO_PIN = 9;
static const uint8_t LIFT_DOWN_DEG = 0;
// 후드는 HOOD_MS 동안 20 ms 간격으로 나눠 옮기고(서보 최고 속도로 큐브·타워를 치지 않게) HOOD_SETTLE_MS 를 기다린다.
// FLIP_SETTLE_MS: 큐브가 65° 를 넘어 떨어져 튐이 멎을 시간(넘어가는 시간 상수 0.074 s × ln(25°/1°) ≈ 0.24 s + 여유).
static const uint16_t HOOD_MS = 300, HOOD_SETTLE_MS = 60, LIFT_UP_MS = 700, LIFT_DOWN_MS = 400, FLIP_SETTLE_MS = 350;   // 뒤집기 합계 약 1.9 s
static const uint8_t REVERSE_MS = 20, SETTLE_MS = 120;   // 컵: 방향을 바꾸기 전 / 마지막 스텝 뒤 정착 시간

// ===== 원본: cube.cpp =====
void Cube::reset() {
  for (uint8_t i = 0; i < 8; i++) { cp[i] = i; co[i] = 0; }
  for (uint8_t i = 0; i < 12; i++) { ep[i] = i; eo[i] = 0; }
}

// s·M :  σ'(i) = σ(σ^M(i)),  o'(i) = o(σ^M(i)) + o^M(i)   (docs/MATH.md 2절)
void Cube::move(uint8_t m) {
  uint8_t ncp[8], nco[8], nep[12], neo[12];
  for (uint8_t i = 0; i < 8; i++) {
    uint8_t j = pgm_read_byte(&MOVE_CP[m][i]);
    ncp[i] = cp[j];
    nco[i] = (co[j] + pgm_read_byte(&MOVE_CO[m][i])) % 3;
  }
  for (uint8_t i = 0; i < 12; i++) {
    uint8_t j = pgm_read_byte(&MOVE_EP[m][i]);
    nep[i] = ep[j];
    neo[i] = (eo[j] + pgm_read_byte(&MOVE_EO[m][i])) & 1;
  }
  memcpy(cp, ncp, 8); memcpy(co, nco, 8); memcpy(ep, nep, 12); memcpy(eo, neo, 12);
}

void Cube::apply(const uint8_t* seq, uint8_t n) { for (uint8_t i = 0; i < n; i++) move(seq[i]); }

bool Cube::isSolved() const {
  for (uint8_t i = 0; i < 8; i++) if (cp[i] != i || co[i]) return false;
  for (uint8_t i = 0; i < 12; i++) if (ep[i] != i || eo[i]) return false;
  return true;
}

// 조각 x 하나의 사영 π_x(s) = (p, o),  p = σ^-1(x) (조각이 있는 위치), o = o(p).
//   엣지 상태 = 2p + o (24가지), 코너 상태 = 3p + o (24가지). 탐색은 이 값만 추적한다 (solver.cpp).
uint8_t Cube::edgeState(uint8_t cubie) const {
  for (uint8_t p = 0; p < 12; p++) if (ep[p] == cubie) return p * 2 + eo[p];
  return 0;
}
uint8_t Cube::cornerState(uint8_t cubie) const {
  for (uint8_t p = 0; p < 8; p++) if (cp[p] == cubie) return p * 3 + co[p];
  return 0;
}

// 스티커 위치표 (sim/cube.js 와 동일)
static const uint8_t CORNER_FACELET[8][3] PROGMEM = {{8, 9, 20}, {6, 18, 38}, {0, 36, 47}, {2, 45, 11}, {29, 26, 15}, {27, 44, 24}, {33, 53, 42}, {35, 17, 51}};
static const uint8_t EDGE_FACELET[12][2] PROGMEM = {{5, 10}, {7, 19}, {3, 37}, {1, 46}, {32, 16}, {28, 25}, {30, 43}, {34, 52}, {23, 12}, {21, 41}, {50, 39}, {48, 14}};
static const uint8_t CORNER_COLOR[8][3] PROGMEM = {{0, 1, 2}, {0, 2, 4}, {0, 4, 5}, {0, 5, 1}, {3, 2, 1}, {3, 4, 2}, {3, 5, 4}, {3, 1, 5}};
static const uint8_t EDGE_COLOR[12][2] PROGMEM = {{0, 1}, {0, 2}, {0, 4}, {0, 5}, {3, 1}, {3, 2}, {3, 4}, {3, 5}, {2, 1}, {2, 4}, {5, 4}, {5, 1}};
static const char FACE_CHARS[] = "URFDLB";

void Cube::facelets(char* out) const {
  for (uint8_t f = 0; f < 6; f++) out[f * 9 + 4] = FACE_CHARS[f];
  for (uint8_t i = 0; i < 8; i++)
    for (uint8_t n = 0; n < 3; n++)
      out[pgm_read_byte(&CORNER_FACELET[i][(n + co[i]) % 3])] = FACE_CHARS[pgm_read_byte(&CORNER_COLOR[cp[i]][n])];
  for (uint8_t i = 0; i < 12; i++)
    for (uint8_t n = 0; n < 2; n++)
      out[pgm_read_byte(&EDGE_FACELET[i][(n + eo[i]) % 2])] = FACE_CHARS[pgm_read_byte(&EDGE_COLOR[ep[i]][n])];
  out[54] = 0;
}

// ---- 표기 ----
void moveName(uint8_t m, char* out) {
  out[0] = FACE_CHARS[m / 3];
  uint8_t k = m % 3;
  out[1] = k == 0 ? 0 : (k == 1 ? '2' : '\'');
  out[2] = 0;
}

void printSeq(Print& p, const uint8_t* seq, uint8_t n) {
  char buf[3];
  for (uint8_t i = 0; i < n; i++) {
    if (i) p.print(' ');
    moveName(seq[i], buf);
    p.print(buf);
  }
}

int8_t parseMove(const char* tok) {
  const char* f = strchr(FACE_CHARS, tok[0]);
  if (!tok[0] || !f) return -1;
  uint8_t k;
  if (tok[1] == 0) k = 0;
  else if (tok[1] == '2' && tok[2] == 0) k = 1;
  else if ((tok[1] == '\'' || tok[1] == '3') && tok[2] == 0) k = 2;
  else return -1;
  return (f - FACE_CHARS) * 3 + k;
}

uint8_t parseSeq(const char* str, uint8_t* out, uint8_t maxN) {
  uint8_t n = 0;
  char tok[4];
  while (*str && n < maxN) {
    while (*str == ' ') str++;
    if (!*str) break;
    uint8_t len = 0;
    while (*str && *str != ' ' && len < 3) tok[len++] = *str++;
    tok[len] = 0;
    while (*str && *str != ' ') str++;  // 너무 긴 토큰 버림
    int8_t m = parseMove(tok);
    if (m < 0) return 0;
    out[n++] = m;
  }
  return n;
}

// 같은 면 연속은 한 수로 합친다: X^a · X^b = X^(a+b mod 4), 0 이면 소거.
uint8_t simplifySeq(uint8_t* seq, uint8_t n) {
  uint8_t out = 0;
  for (uint8_t i = 0; i < n; i++) {
    uint8_t m = seq[i];
    if (out && seq[out - 1] / 3 == m / 3) {
      uint8_t f = m / 3;
      uint8_t t = ((seq[out - 1] % 3) + 1 + (m % 3) + 1) % 4;
      out--;
      if (t) seq[out++] = f * 3 + t - 1;
    } else seq[out++] = m;
  }
  return out;
}

// xorshift32: x ^= x<<13; x ^= x>>17; x ^= x<<5 (주기 2^32-1, 시드 0 은 0x9E3779B9 로 대체).
// 면 f = x mod 6 (직전 면과 같으면 버림), 회전 k = x' mod 3. JS(sim/cube.js) 와 같은 32비트 산술이라
// 같은 시드 → 같은 수열. 이것이 "JS 기대 출력 = 보드 출력" 교차검증의 전제다 (docs/MATH.md 9절).
void scrambleSeq(uint32_t seed, uint8_t* out, uint8_t n) {
  uint32_t s = seed ? seed : 0x9E3779B9UL;
  int8_t last = -1;
  uint8_t i = 0;
  while (i < n) {
    s ^= s << 13; s ^= s >> 17; s ^= s << 5;
    uint8_t f = s % 6;
    if ((int8_t)f == last) continue;
    s ^= s << 13; s ^= s >> 17; s ^= s << 5;
    out[i++] = f * 3 + s % 3;
    last = f;
  }
}

// ===== 원본: solver.cpp =====
static const uint8_t MAX_DEPTH = 14;       // 크로스 안전 한계 (크로스는 항상 8수 이내)
static const uint8_t F2L_MAX_BOUND = 20;   // F2L 한 쌍 안전 한계 (생성기 전수 검사: 최장 11수)
static const uint8_t N_MACROS = 27;
static const char SLOT_NAMES[4][3] = {"FR", "FL", "BL", "BR"};

// 코너 상태(위치*3+방향)의 위치. AVR에서 매번 /3, %3을 계산하지 않는다.
static const uint8_t CORNER_POS[24] PROGMEM = {
  0,0,0, 1,1,1, 2,2,2, 3,3,3, 4,4,4, 5,5,5, 6,6,6, 7,7,7
};

// 조각 상태 전이 T_M(p, o) = (q, o + o^M(q)),  q = (σ^M)^-1(p)  — EDGE_TO[m][p] = q, EDGE_DO[m][p] = o^M(q).
// 등변성 π_x(s·M) = T_M(π_x(s)) 덕분에 전체 상태 없이 조각 상태만으로 정확히 같은 값을 얻는다 (docs/MATH.md 3절).
// 같은 수로 여러 조각을 갱신하므로 이동표의 행 주소는 한 번만 구한다.
static inline __attribute__((always_inline)) uint8_t eStep(uint8_t s, const uint8_t* to, const uint8_t* delta) {
  uint8_t p = s >> 1;
  return (pgm_read_byte(to + p) << 1) | ((s + pgm_read_byte(delta + p)) & 1);
}
static inline __attribute__((always_inline)) uint8_t cStep(uint8_t s, const uint8_t* to, const uint8_t* delta) {
  uint8_t p = pgm_read_byte(CORNER_POS + s);
  uint8_t ori = s - p * 3 + pgm_read_byte(delta + p);  // 0..4
  if (ori >= 3) ori -= 3;
  return pgm_read_byte(to + p) * 3 + ori;
}

// key_OLL(s) = (Σ_{i<4} oc(i)·3^(3-i)) · 2^4 + Σ_{i<4} oe(i)·2^(3-i)  ∈ [0, 1295]  — U층 코너·엣지 방향만.
//   방향은 위치와 무관한 아핀 함수로 변하므로 (o'(i) = o(σ^A(i)) + o^A(i)) 방향만으로 OLL 경우가 결정된다.
//   유효 OLL 상태 수 = 27 (Σoc≡0) × 8 (Σoe≡0) = 216, U 회전으로 묶으면 57 경우 + 풀린 1.
static uint16_t ollKey(const Cube& c) {
  return ((((c.co[0] * 3 + c.co[1]) * 3 + c.co[2]) * 3 + c.co[3]) << 4) | (c.eo[0] << 3) | (c.eo[1] << 2) | (c.eo[2] << 1) | c.eo[3];
}
// key_PLL(s) = Σ_{i<4} σc(i)·2^(14-2i) + Σ_{i<4} σe(i)·2^(6-2i)  ∈ [0, 2^16)  — U층 위치만 (방향은 이미 0).
//   유효 PLL 상태 수 = 24 × 24 / 2 (부호 일치) = 288, 사전·사후 U 조정으로 묶으면 21 경우 + 풀린 1.
static uint16_t pllKey(const Cube& c) {
  return ((uint16_t)c.cp[0] << 14) | ((uint16_t)c.cp[1] << 12) | ((uint16_t)c.cp[2] << 10) | ((uint16_t)c.cp[3] << 8) | (c.ep[0] << 6) | (c.ep[1] << 4) | (c.ep[2] << 2) | c.ep[3];
}

// ======================= Cross =======================
// h_cross(s) = max over 6 쌍 {a,b} ⊂ {DR,DF,DL,DB} of d_{a,b}(π_a(s), π_b(s)).
//   각 d_{a,b} 는 두 엣지의 사영 그래프(24×24) 에서의 BFS 거리 → 허용적, 최댓값도 허용적 (docs/MATH.md 4절).
//   쌍 표는 한 조각 표보다 강하다: d_{a,b} ≥ max(d_a, d_b) 이고 서로 길을 막는 경우를 반영 (표 최댓값 5).
//   limit 초과 값은 바로 반환해도 "max > limit" 판정은 같다 (조기 탈출).
inline __attribute__((always_inline)) uint8_t Solver::hCross(const uint8_t* es, uint8_t limit) const {
  uint8_t h = 0;
  const uint8_t* table = &CROSS_PAIR[0][0];
  for (uint8_t i = 0; i < 6; i++) {
    uint8_t d = pgm_read_byte(table + es[crossA[i]] * 24 + es[crossB[i]]);
    if (d > limit) return d;
    if (d > h) h = d;
    table += 576;
  }
  return h;
}

// 자식 n' 의 IDA* 조건  g+1+h(n') ≤ bound  ⇔  h(n') ≤ bound-g-1 =: limit.
// h 는 거리표들의 최댓값이므로 거리표 중 하나라도 limit 를 넘으면 최댓값도 넘는다 → 조기 탈출.
inline __attribute__((always_inline)) bool Solver::childFits(const uint8_t* es, uint8_t* es2, uint8_t m, uint8_t limit, uint8_t& h) const {
  const uint8_t* et = EDGE_TO[m];
  const uint8_t* ed = EDGE_DO[m];
  for (uint8_t i = 0; i < 4; i++) es2[i] = eStep(es[i], et, ed);
  h = hCross(es2, limit);
  return h <= limit;
}

// IDA*: f = g + h ≤ bound 인 노드만 내려간다 (remaining = bound - g).
//   중복 수열 제거 — 같은 면 연속 금지 (X^a X^b = X^(a+b) 로 한 수), 반대면은 가환 (U D = D U) 이라
//   면 번호가 작은 쪽을 먼저 오는 순서만 허용 (U D 허용, D U 금지). 분기 18 → 평균 ≈ 13.3.
//   h 가 허용적이므로 bound 를 h(s0) 부터 1씩 올리며 처음 찾는 해는 허용 수 집합 안에서 최단이다.
// 진입 시 휴리스틱 검사는 끝난 상태. 탈락할 자식에 대한 재귀 호출을 생략한다.
bool Solver::searchCross(const uint8_t* es, uint8_t g, uint8_t remaining, int8_t lastFace) {
  uint8_t es2[4];
  uint8_t limit = remaining - 1;
  for (int8_t f = 0; f < 6; f++) {
    if (f == lastFace) continue;
    if (lastFace >= 3 && f == lastFace - 3) continue;
    // f*3, f*3+1, f*3+2 순서이므로 원래 m=0..17 순서와 같다.
    uint8_t end = f * 3 + 3;
    for (uint8_t m = end - 3; m < end; m++) {
      nodes++;  // 생성한 자식마다 한 번, 반드시 그 자식의 휴리스틱 검사 전
      uint8_t h;
      if (!childFits(es, es2, m, limit, h)) continue;
      path[g] = m;
      if (h == 0) { pathLen = g + 1; return true; }
      if (searchCross(es2, g + 1, limit, f)) return true;
    }
  }
  return false;
}

bool Solver::idaCross(const uint8_t* es, uint8_t maxBound) {
  // 이번 IDA* 동안 변하지 않는 쌍 번호를 미리 읽는다.
  for (uint8_t i = 0; i < 6; i++) {
    crossA[i] = pgm_read_byte(&CROSS_PAIRS[i][0]) - 4;
    crossB[i] = pgm_read_byte(&CROSS_PAIRS[i][1]) - 4;
  }
  uint8_t h = hCross(es, 255);
  if (h == 0) { pathLen = 0; return true; }
  for (uint8_t bound = h; bound <= maxBound; bound++)
    if (searchCross(es, 0, bound, -1)) return true;
  return false;
}

// ======================= F2L =======================
// 매크로 번호 i → 겉면 수열. 0..2 = U U2 U' (비용 1), 3 + (slot*2+fam)*3 + k = X U^(k+1) X^-1 (비용 3),
//   X = F2L_TRIG[slot][fam] (fam 0: a U^k a', fam 1: b' U^k b).  sim/solver.js 의 MACROS 와 같은 번호·같은 수열.
uint8_t Solver::macroMoves(uint8_t i, uint8_t* out) {
  if (i < 3) { out[0] = FACE_U * 3 + i; return 1; }
  uint8_t t = i - 3;
  uint8_t X = pgm_read_byte(&F2L_TRIG[t / 6][(t / 3) & 1]);
  out[0] = X;
  out[1] = FACE_U * 3 + t % 3;
  out[2] = (X / 3) * 3 + 2 - X % 3;  // X 의 역수
  return 3;
}
uint8_t Solver::macroKind(uint8_t i) { return i < 3 ? 0xFF : (i - 3) / 3; }

// 매크로 IDA*: 상태 = 쌍 (cs, es) 2바이트, h = F2L_PAIR[slot] (매크로 그래프의 최단 겉면 수, 255 = 도달 불가).
//   allowedMask 비트 q = 슬롯 q 의 트리거 허용(미완성 슬롯). 완성 슬롯의 트리거를 금지하면 표 값은 하한이 된다.
//   같은 종류 연속 금지: U U = 한 수, (X U^a X')(X U^b X') = X U^(a+b) X'.  g 는 겉면 수, depth 는 매크로 수.
bool Solver::searchF2L(uint8_t cs, uint8_t es, uint8_t g, uint8_t depth, uint8_t bound, int8_t last, const uint8_t* table, uint8_t allowedMask) {
  uint8_t h = pgm_read_byte(table + cs * 24 + es);
  if (h == 255 || g + h > bound) return false;
  if (h == 0) { mpathLen = depth; return true; }
  uint8_t mv[3];
  for (uint8_t i = 0; i < N_MACROS; i++) {
    if (i >= 3 && !(allowedMask & (1 << ((i - 3) / 6)))) continue;
    if (last >= 0 && macroKind(last) == macroKind(i)) continue;
    nodes++;  // 전개한 매크로마다 한 번 (sim/solver.js 와 같은 셈)
    uint8_t n = macroMoves(i, mv);
    uint8_t c2 = cs, e2 = es;
    for (uint8_t j = 0; j < n; j++) {
      c2 = cStep(c2, CORNER_TO[mv[j]], CORNER_DO[mv[j]]);
      e2 = eStep(e2, EDGE_TO[mv[j]], EDGE_DO[mv[j]]);
    }
    mpath[depth] = i;
    if (searchF2L(c2, e2, g + n, depth + 1, bound, i, table, allowedMask)) return true;
  }
  return false;
}

// ======================= OLL / PLL =======================
// s·r·A 가 방향 0  ⇔  key_OLL(s·r) = key_OLL(I·A^-1).  r ∈ {id, U, U2, U'} 순서로 첫 매치 (sim/solver.js 와 동일 순서).
bool Solver::lookupOLL(const Cube& c, uint8_t* out, uint8_t& n, char* name) {
  for (uint8_t r = 0; r < 4; r++) {
    Cube t = c;
    if (r) t.move(FACE_U * 3 + r - 1);
    uint16_t key = ollKey(t);
    n = 0;
    if (r) out[n++] = FACE_U * 3 + r - 1;
    if (key == 0) { strcpy(name, "OLL skip"); return true; }
    for (uint8_t i = 0; i < OLL_COUNT; i++) {
      if (pgm_read_word(&OLL_KEY[i]) != key) continue;
      uint16_t a = pgm_read_word(&OLL_OFF[i]), b = pgm_read_word(&OLL_OFF[i + 1]);
      for (uint16_t k = a; k < b; k++) out[n++] = pgm_read_byte(&OLL_MOVES[k]);
      sprintf(name, "OLL %u", pgm_read_byte(&OLL_NUM[i]));
      return true;
    }
  }
  return false;
}

// s·r·A·u = I  ⇔  s·r = u^-1·A^-1.  표의 각 항목은 (A, u) 와 key_PLL(I·u^-1·A^-1); 매치되면 풀이 = r, A, u.
bool Solver::lookupPLL(const Cube& c, uint8_t* out, uint8_t& n, char* name) {
  Cube solved;
  uint16_t solvedKey = pllKey(solved);
  for (uint8_t r = 0; r < 4; r++) {
    Cube t = c;
    if (r) t.move(FACE_U * 3 + r - 1);
    uint16_t key = pllKey(t);
    n = 0;
    if (r) out[n++] = FACE_U * 3 + r - 1;
    if (key == solvedKey) { strcpy(name, "PLL skip"); return true; }
    for (uint8_t i = 0; i < PLL_COUNT; i++) {
      if (pgm_read_word(&PLL_KEY[i]) != key) continue;
      uint16_t a = pgm_read_word(&PLL_OFF[i]), b = pgm_read_word(&PLL_OFF[i + 1]);
      for (uint16_t k = a; k < b; k++) out[n++] = pgm_read_byte(&PLL_MOVES[k]);
      uint8_t auf = pgm_read_byte(&PLL_AUF[i]);
      if (auf) out[n++] = FACE_U * 3 + auf - 1;
      strcpy(name, "PLL ");
      strcpy_P(name + 4, PLL_NAMES[pgm_read_byte(&PLL_NAME_IDX[i])]);
      return true;
    }
  }
  return false;
}

// ======================= 전체 =======================
bool Solver::solve(const Cube& start, uint8_t* out, uint8_t& outLen, StageCallback cb) {
  Cube c = start;
  outLen = 0; nodes = 0;
  uint8_t stage[STAGE_MAX], stageLen;
  char name[12];

  // 1. Cross — 크로스 엣지 DR DF DL DB 의 상태만 추적
  uint32_t t0 = millis(), n0 = nodes;
  uint8_t es[4];
  for (uint8_t i = 0; i < 4; i++) es[i] = c.edgeState(4 + i);
  if (!idaCross(es, MAX_DEPTH)) return false;
  memcpy(stage, path, pathLen); stageLen = pathLen;
  c.apply(stage, stageLen); memcpy(out + outLen, stage, stageLen); outLen += stageLen;
  if (cb) cb("CROSS", stage, stageLen, nodes - n0, millis() - t0);

  // 2. F2L — 쌍마다 가장 쉬운 슬롯부터 (그리디)
  uint8_t allowedMask = 0x0F;  // 미완성 슬롯 비트
  for (uint8_t k = 0; k < 4; k++) {
    t0 = millis(); n0 = nodes;
    // 후보 슬롯: 거리표 값 오름차순, 같으면 번호 순 (삽입 정렬)
    uint8_t cand[4], candD[4], candC[4], candE[4], nc = 0;
    for (uint8_t s = 0; s < 4; s++) {
      if (!(allowedMask & (1 << s))) continue;
      uint8_t cs = c.cornerState(4 + s), e = c.edgeState(8 + s);
      uint8_t d = pgm_read_byte(&F2L_PAIR[s][cs * 24 + e]), j = nc;
      while (j > 0 && candD[j - 1] > d) { cand[j] = cand[j - 1]; candD[j] = candD[j - 1]; candC[j] = candC[j - 1]; candE[j] = candE[j - 1]; j--; }
      cand[j] = s; candD[j] = d; candC[j] = cs; candE[j] = e; nc++;
    }
    // 한계 B 를 가장 작은 표 값부터 1씩 올리며 B 안에 풀리는 첫 후보를 택한다
    int8_t chosen = -1;
    for (uint8_t B = candD[0]; B <= F2L_MAX_BOUND && chosen < 0; B++) {
      for (uint8_t i = 0; i < nc; i++) {
        if (candD[i] > B) continue;
        if (searchF2L(candC[i], candE[i], 0, 0, B, -1, F2L_PAIR[cand[i]], allowedMask)) { chosen = cand[i]; break; }
      }
    }
    if (chosen < 0) return false;
    stageLen = 0;
    for (uint8_t i = 0; i < mpathLen; i++) stageLen += macroMoves(mpath[i], stage + stageLen);
    stageLen = simplifySeq(stage, stageLen);  // 트리거 경계의 같은 면 연속(R' R 등)을 합친다
    c.apply(stage, stageLen); memcpy(out + outLen, stage, stageLen); outLen += stageLen;
    allowedMask &= ~(1 << chosen);
    strcpy(name, "F2L "); strcat(name, SLOT_NAMES[chosen]);
    if (cb) cb(name, stage, stageLen, nodes - n0, millis() - t0);
  }

  // 3. OLL
  t0 = millis(); n0 = nodes;
  if (!lookupOLL(c, stage, stageLen, name)) return false;
  c.apply(stage, stageLen); memcpy(out + outLen, stage, stageLen); outLen += stageLen;
  if (cb) cb(name, stage, stageLen, 0, millis() - t0);

  // 4. PLL
  t0 = millis();
  if (!lookupPLL(c, stage, stageLen, name)) return false;
  c.apply(stage, stageLen); memcpy(out + outLen, stage, stageLen); outLen += stageLen;
  if (cb) cb(name, stage, stageLen, 0, millis() - t0);

  if (!c.isSolved()) return false;
  outLen = simplifySeq(out, outLen);
  return true;
}

// ===== 원본: motors.cpp =====
void Motors::begin() {
  pinMode(STEP_PIN, OUTPUT); digitalWrite(STEP_PIN, LOW);
  pinMode(DIR_PIN, OUTPUT); digitalWrite(DIR_PIN, LOW);
  pinMode(EN_PIN, OUTPUT); digitalWrite(EN_PIN, LOW);         // 켬 (유지 토크로 컵 위치를 지킨다)
}

void Motors::hold(bool on) { digitalWrite(EN_PIN, on ? LOW : HIGH); }

void Motors::setDir(bool cw) {
  digitalWrite(DIR_PIN, cw ? CW_LEVEL : !CW_LEVEL);
  delayMicroseconds(5);                                       // A4988 DIR 셋업 시간
}

void Motors::pulse(uint16_t gapUs) {
  digitalWrite(STEP_PIN, HIGH);
  delayMicroseconds(3);
  digitalWrite(STEP_PIN, LOW);
  delayMicroseconds(gapUs);
}

// 등가속 사다리꼴. c = 스텝 간격(1/16 µs 고정소수), n = 지금 속도까지 가속한 스텝 수(= 멈추는 데 필요한 스텝 수).
void Motors::rotate(uint16_t steps, bool cw) {
  if (!enabled || steps == 0) { lastMoveMs = 0; return; }
  uint32_t t0 = millis();
  setDir(cw);
  const uint32_t cMin = (uint32_t)MIN_US << 4;
  uint32_t c = (uint32_t)START_US << 4;
  uint16_t n = 0;
  for (uint16_t left = steps; left > 0; left--) {
    pulse((uint16_t)(c >> 4));
    uint16_t r = left - 1;                                    // 남은 펄스 수
    if (r <= n) {                                             // 남은 스텝으로 멈춰야 한다: 감속
      if (n) { c += 2 * c / (4UL * n - 1); n--; }
    } else if (r >= n + 2 && c > cMin) {                      // 가속 — 한 단계 올려도 같은 곡선으로 내려올 스텝이 남을 때만
                                                              //   (짝수 짧은 이동도 첫·끝 간격이 같아진다. MIN_US 에 닿으면 등속)
      n++; c -= 2 * c / (4UL * n + 1);
      if (c < cMin) c = cMin;
    }
  }
  lastMoveMs = millis() - t0;
}

// ===== 원본: mechanism.cpp =====
static const char HOOD_NAME[3][6] = {"CLOSE", "OPEN", "LOAD"};
static const char SPIN_NAME[4][3] = {"", "y", "y2", "y'"};
static const char TURN_NAME[3][3] = {"D", "D2", "D'"};
static const uint8_t ORI_START[6] = {3, 4, 2, 0, 1, 5};   // 장착 = z2: 흰색(논리 U) 아래, 초록(논리 F) 앞
// 물리 위치별 재배향: 0 = 끝, 1..3 = SPIN y^k, 9 = FLIP (sim/mechanism.js REORIENT 와 같은 순서)
static const uint8_t REORIENT[6][3] = {
  {9, 9, 0},   // U: FLIP FLIP
  {1, 9, 0},   // R: SPIN y, FLIP
  {9, 0, 0},   // F: FLIP
  {0, 0, 0},   // D: 없음
  {3, 9, 0},   // L: SPIN y', FLIP
  {2, 9, 0},   // B: SPIN y2, FLIP
};

void Mechanism::resetOri() { memcpy(ori, ORI_START, 6); }

bool Mechanism::ready() {
  if (virt() || loaded) return true;
  Serial.println(F("ERR not loaded"));
  return false;
}

void Mechanism::begin(Motors* m) {
  motors = m;
  resetOri();
  hood.attach(HOOD_SERVO_PIN);
  lift.attach(LIFT_SERVO_PIN);
  hoodNow = hoodDeg[HOOD_OPEN];
  hood.write(hoodNow);
  lift.write(LIFT_DOWN_DEG);
  hoodPos = HOOD_OPEN;
}

// 서보를 20 ms 간격으로 조금씩 옮겨 준정적으로 움직인다 (리프터가 큐브를 천천히 끌어올리도록)
void Mechanism::sweep(Servo& s, uint8_t from, uint8_t to, uint16_t ms) {
  if (from == to) return;
  uint8_t n = ms / 20; if (n == 0) n = 1;
  for (uint8_t i = 1; i <= n; i++) {
    s.write(from + ((int16_t)to - from) * i / n);
    delay(20);
  }
}

void Mechanism::hoodTo(uint8_t deg, uint16_t ms) { sweep(hood, hoodNow, deg, ms); hoodNow = deg; }

void Mechanism::rehood() { if (!virt()) hoodTo(hoodDeg[hoodPos], HOOD_MS); }

// 줄·횟수는 논리 상태(hoodPos)가 바뀔 때만 낸다(sim/mechanism.js 와 같다). 서보는 실제 각(hoodNow)이 다르면 항상 옮긴다 —
// 가상 모드(Q 1)에서 논리 상태만 CLOSE 가 된 뒤 Q 0 으로 돌아와도 실물 후드가 열린 채 층 회전하지 않게.
void Mechanism::setHood(uint8_t pos) {
  if (hoodPos != pos) {
    Serial.print(F("HOOD ")); Serial.println(HOOD_NAME[pos]);
    hoods++;
    hoodPos = pos;
  }
  if (!virt() && hoodNow != hoodDeg[pos]) { hoodTo(hoodDeg[pos], HOOD_MS); delay(HOOD_SETTLE_MS); }
}

// 컵 회전 + 여유 보정 (mechanism.h 머리말): steps+over 전진 → over+play 후진 → play 전진. 스텝 합 = steps.
void Mechanism::cupMove(uint16_t steps, bool cw, uint8_t over) {
  if (virt()) return;
  motors->rotate(steps + over, cw);
  if (over + playSteps) { delay(REVERSE_MS); motors->rotate(over + playSteps, !cw); }
  if (playSteps) { delay(REVERSE_MS); motors->rotate(playSteps, cw); }
  delay(SETTLE_MS);
}

// 큐브 전체 y^k: 후드를 열고 컵을 위에서 봐서 시계 방향으로 k×90° (y' 는 반시계 1회)
bool Mechanism::spin(uint8_t k) {
  if (!ready()) return false;
  setHood(HOOD_OPEN);
  for (uint8_t i = 0; i < k; i++) {                      // y: F←R, L←F, B←L, R←B
    uint8_t r = ori[1], f = ori[2], l = ori[4], b = ori[5];
    ori[2] = r; ori[4] = f; ori[5] = l; ori[1] = b;
  }
  spins++;
  Serial.print(F("SPIN ")); Serial.println(SPIN_NAME[k]);
  cupMove(k == 3 ? STEPS_PER_QUARTER : STEPS_PER_QUARTER * k, k != 3, playSteps);
  return true;
}

// 뒤집기 x': 후드 90°(서보 105°) → 리프터가 뒤쪽 아래 모서리를 끌어올려 큐브가 앞으로 넘어진다 → 리프터 내림
//   → 후드가 60° 로 돌아오는 동안 컵을 ±play 왕복해 착지한 큐브를 기둥 사이 가운데로 민다
bool Mechanism::flip() {
  if (!ready()) return false;
  setHood(HOOD_OPEN);
  uint8_t u = ori[0], f = ori[2], d = ori[3], b = ori[5];
  ori[3] = f; ori[5] = d; ori[0] = b; ori[2] = u;
  flips++;
  Serial.println(F("FLIP"));
  if (!virt()) {
    hoodTo(hoodFlipDeg, HOOD_MS / 2);
    sweep(lift, LIFT_DOWN_DEG, liftUpDeg, LIFT_UP_MS);
    delay(FLIP_SETTLE_MS);                                 // 큐브가 자리에 떨어져 튐이 멎을 시간
    sweep(lift, liftUpDeg, LIFT_DOWN_DEG, LIFT_DOWN_MS);   // 리프터가 판 아래로 완전히 내려온 뒤에만 컵을 움직인다
    hoodNow = hoodDeg[HOOD_OPEN]; hood.write(hoodNow);     // 30° 복귀는 아래 중심 맞춤 동안 끝난다
    cupMove(0, true, playSteps);
    delay(HOOD_MS / 2 - SETTLE_MS);
  }
  return true;
}

bool Mechanism::doMove(uint8_t m) {
  if (!ready()) return false;
  uint8_t f = m / 3, k = m % 3;
  uint8_t p = 0;
  while (p < 6 && ori[p] != f) p++;
  for (uint8_t i = 0; i < 3 && REORIENT[p][i]; i++) {
    uint8_t op = REORIENT[p][i];
    if (op == 9) { if (!flip()) return false; }
    else if (!spin(op)) return false;
  }
  setHood(HOOD_CLOSE);
  Serial.print(F("TURN ")); Serial.println(TURN_NAME[k]);
  // D = 아래에서 봐서 시계 = 컵을 위에서 봐서 반시계. k 0: 1/4 반시계, 1: 1/2, 2: 1/4 시계
  cupMove((k == 1) ? 2 * STEPS_PER_QUARTER : STEPS_PER_QUARTER, k == 2, overshootSteps);
  return true;
}

// LOAD 버튼 한 단계. 후드를 뒤로 젖힌 LOAD 자세에서 큐브를 위에서 내려놓는다(흰색 아래, 초록 앞).
bool Mechanism::load() {
  if (loaded) return eject();
  if (hoodPos != HOOD_LOAD) {
    setHood(HOOD_LOAD);
    if (!virt()) lift.write(LIFT_DOWN_DEG);
    Serial.println(F("READY TO LOAD"));
    return true;
  }
  setHood(HOOD_OPEN);
  loaded = true; resetOri();
  Serial.println(F("LOADED"));
  return true;
}

bool Mechanism::eject() {
  Serial.println(F("EJECT"));
  setHood(HOOD_LOAD);
  loaded = false;
  Serial.println(F("EJECTED"));
  return true;
}

void Mechanism::printStatus(Print& p) {
  static const char FACE[6] = {'U', 'R', 'F', 'D', 'L', 'B'};
  p.print(F("MECH hood=")); p.print(HOOD_NAME[hoodPos]); p.print(F(" ori="));
  for (uint8_t i = 0; i < 6; i++) p.print(FACE[ori[i]]);
  p.print(F(" loaded=")); p.print(loaded);
  p.print(F(" flips=")); p.print(flips); p.print(F(" spins=")); p.print(spins); p.print(F(" hoods=")); p.println(hoods);
}

// ===== 원본: main.ino =====
// main.ino — 3x3 큐브 풀이 로봇 V5 (컴퓨터과학2 피지컬 컴퓨팅)
//
// 보드: Arduino UNO R4 WiFi (실물) / UNO R3 (Wokwi 시뮬레이션, 헤더 핀 배치 동일)
// 기구 (docs/HARDWARE_V5.md): 시중 57 mm 큐브를 20° 기울어진 컵(홀더)에 넣는다. 컵은 NEMA17 직결 —
//       후드(MG996R)가 닫혀 위 두 층을 잡으면 아래 층이 돌고(TURN), 열려 있으면 큐브 전체가 돈다(SPIN y).
//       리프터(SG90, 직선 슬롯 크랭크)가 뒤쪽 아래 모서리를 끌어올려 큐브를 앞으로 넘긴다(FLIP = x').
//       모든 층 회전은 아래에서만 하므로 논리 면을 아래로 가져오는 재배향(스핀·뒤집기)을 Mechanism 이 끼워 넣는다.
// 회로: A4988 ×1 (STEP D2, DIR D7, EN D6), 후드 서보 D8, 리프터 서보 D9,
//       버튼 1개 A2 (풀업; 짧게 = START, 1.2 s 이상 = LOAD), 부저 A3, LCD1602 I2C(A4/A5). 센서 없음.
//
// 동작: [LOAD 길게]  후드를 뒤로 젖힌다(READY TO LOAD) → 큐브를 흰색 아래·초록 앞으로 넣고 다시 길게 누르면 후드가 열린 자세로 돌아오며 장착(LOADED).
//                    장착된 상태에서 길게 누르면 배출(후드 LOAD 자세, 손으로 꺼냄).
//       [START 짧게] 모델이 풀린 상태면 섞기, 아니면 풀기 (한 버튼으로 섞기 → 풀기 → 섞기 … 반복).
//       [SCRAMBLE] 로봇이 20수 무작위 섞기를 직접 돌리며 그 수열을 기록한다 → 큐브 상태를 센서 없이 정확히 안다.
//       [SOLVE]    보드 안에서 CFOP(크로스·F2L IDA*, OLL·PLL 표 조회)로 풀이를 계산하고 모터로 실행한다.
// 시리얼(115200) 접점 규칙 — 모든 명령은 한 줄, 수열은 "R U R' U2" 표기:
//   S [seed]   섞기 (seed 생략 시 micros 기반). 출력: SCRAMBLE seed=<n> (20): <수열>
//   V          풀기. 단계마다 "<이름> (<수>): <수열> | nodes=.. ms=.." 출력 후 TOTAL, 실행, SOLVED ok=1
//   M <수열>   임의 수열 실행 (PC 시뮬레이터·스마트큐브 입력용)
//   L / E      장착 한 단계(LOAD 버튼과 같음) / 배출
//   F / Y <k>  시연용 뒤집기 / 스핀 y^k (k 1..3)
//   P          현재 상태 54 스티커 출력 (STATE URRF...) + MECH 상태      R  모델을 풀린 상태로 리셋
//   Q 0|1      가상 모드(1=모터·서보 생략, 절차는 출력)
//   H c o l    후드 서보 각 CLOSE/OPEN/LOAD 조정 (기본 15 75 135, 지금 자세에 바로 적용)   K <각> 리프터 최상 각 (기본 180)
//   O <o> [p]  층 회전 오버슈트 o 스텝 (기본 12 = 5.4°) / 컵 한쪽 여유 p 스텝 (기본 5 = 2.25°, 0 = 중심 맞춤 끔). 1 스텝 = 0.45°
//   J <±n>     컵을 n 스텝 미세 회전(+ = 위에서 봐서 시계). 큐브 모델·자세는 그대로 — 전원을 켠 뒤 컵 영점(노치가 정확히 뒤)을 맞출 때

static const uint8_t BTN_PIN = A2, BUZZER = A3;      // 버튼 1개 (풀업, GND). 핀이 모자라 짧게/길게로 두 기능
static const unsigned long LONG_PRESS_MS = 1200;
static const uint8_t SCRAMBLE_LEN = 20;
static const unsigned long DEBOUNCE_MS = 30;

LiquidCrystal_I2C lcd(0x27, 16, 2);
Cube cube;
Solver solver;
Motors motors;
Mechanism mech;
uint8_t solution[SOL_MAX];
uint8_t solutionLen = 0;
uint32_t lastSeed = 0;
char line[96];
uint8_t lineLen = 0;
char row1[17];                                       // LCD 둘째 줄 조립용

// ---- LCD ---- (row0 는 RAM 문자열·F() 문자열 모두 받는다)
template <class T> void lcdShow(T row0, const char* row1) {
  lcd.clear();
  lcd.setCursor(0, 0); lcd.print(row0);
  lcd.setCursor(0, 1); lcd.print(row1);
}

void beep(uint16_t hz, uint16_t ms) { tone(BUZZER, hz, ms); delay(ms); }
void fail(const __FlashStringHelper* row0, const char* row1) { lcdShow(row0, row1); beep(220, 400); }

// ---- 수열 실행: 지지 전환(+뒤집기) → 물리 수 회전 → 모델 갱신 ----
bool execute(const uint8_t* seq, uint8_t n, const __FlashStringHelper* label) {
  for (uint8_t i = 0; i < n; i++) {
    if (!mech.doMove(seq[i])) {
      Serial.print(F("ABORTED completed=")); Serial.println(i);
      fail(F("ABORTED"), "state retained");
      return false;
    }
    cube.move(seq[i]);
    if ((i & 3) == 0 || i == n - 1) {
      snprintf(row1, sizeof(row1), "%u/%u", i + 1, n);
      lcdShow(label, row1);
    }
  }
  return true;
}

void printMechStats() {
  Serial.print(F(" flips=")); Serial.print(mech.flips); Serial.print(F(" spins=")); Serial.print(mech.spins);
}

// ---- 섞기 ----
void doScramble(uint32_t seed) {
  uint8_t seq[SCRAMBLE_LEN];
  lastSeed = seed;
  scrambleSeq(seed, seq, SCRAMBLE_LEN);
  Serial.print(F("SCRAMBLE seed=")); Serial.print(seed);
  Serial.print(F(" (")); Serial.print(SCRAMBLE_LEN); Serial.print(F("): "));
  printSeq(Serial, seq, SCRAMBLE_LEN); Serial.println();
  mech.resetCounters();
  uint32_t t0 = millis();
  if (!execute(seq, SCRAMBLE_LEN, F("SCRAMBLING"))) return;
  snprintf(row1, sizeof(row1), "seed %lu", (unsigned long)seed);
  lcdShow(F("SCRAMBLED 20mv"), row1);
  Serial.print(F("SCRAMBLED exec=")); Serial.print(millis() - t0); Serial.print(F("ms"));
  printMechStats(); Serial.println();
  beep(880, 80);
}

// ---- 풀기 ----
void onStage(const char* name, const uint8_t* moves, uint8_t n, uint32_t nodes, uint32_t ms) {
  Serial.print(name); Serial.print(F(" (")); Serial.print(n); Serial.print(F("): "));
  printSeq(Serial, moves, n);
  Serial.print(F(" | nodes=")); Serial.print(nodes); Serial.print(F(" ms=")); Serial.println(ms);
  snprintf(row1, sizeof(row1), "%u mv %lu ms", n, (unsigned long)ms);
  lcdShow(name, row1);
}

void doSolve() {
  if (cube.isSolved()) { Serial.println(F("ALREADY SOLVED")); lcdShow(F("ALREADY SOLVED"), ""); return; }
  Serial.println(F("SOLVING"));  // "SOLVED" 의 접두사가 되지 않도록 (시나리오 매칭)
  lcdShow(F("SOLVING..."), "cross");
  uint32_t t0 = millis();
  bool ok = solver.solve(cube, solution, solutionLen, onStage);
  uint32_t calcMs = millis() - t0;
  if (!ok) { Serial.println(F("SOLVE FAILED (invalid state)")); fail(F("SOLVE FAILED"), "check cube"); return; }
  Serial.print(F("TOTAL ")); Serial.print(solutionLen); Serial.print(F(": "));
  printSeq(Serial, solution, solutionLen); Serial.println();
  Serial.print(F("CALC nodes=")); Serial.print(solver.nodes); Serial.print(F(" ms=")); Serial.println(calcMs);
  mech.resetCounters();
  t0 = millis();
  if (!execute(solution, solutionLen, F("EXECUTING"))) return;
  uint32_t execMs = millis() - t0;
  bool solved = cube.isSolved();
  Serial.print(F("SOLVED ok=")); Serial.print(solved ? 1 : 0);
  Serial.print(F(" moves=")); Serial.print(solutionLen);
  printMechStats();
  Serial.print(F(" calc=")); Serial.print(calcMs); Serial.print(F("ms exec=")); Serial.print(execMs); Serial.println(F("ms"));
  snprintf(row1, sizeof(row1), "%umv %lu.%lus", solutionLen, (unsigned long)((calcMs + execMs) / 1000), (unsigned long)(((calcMs + execMs) % 1000) / 100));
  lcdShow(solved ? F("SOLVED!") : F("MISMATCH"), row1);
  beep(1047, 100); beep(1319, 100); beep(1568, 160);
}

void printState() {
  char fc[55];
  cube.facelets(fc);
  Serial.print(F("STATE ")); Serial.println(fc);
  mech.printStatus(Serial);
}

// ---- 장착 / 배출 (LOAD 버튼 = 'L') ----
void doLoad() {
  bool wasLoaded = mech.isLoaded();
  if (!mech.load()) { fail(F("LOAD FAILED"), "check hood"); return; }
  if (wasLoaded) lcdShow(F("REMOVE CUBE"), "LOAD: next cube");
  else if (mech.waitingForCube()) lcdShow(F("PLACE CUBE SOLVED"), "WHITE DOWN GRN FRONT");
  else { lcdShow(F("CUBE LOADED"), "SCRAMBLE / SOLVE"); beep(880, 80); }
}
void doEject() {
  if (!mech.isLoaded()) { Serial.println(F("ERR not loaded")); return; }
  if (!mech.eject()) { fail(F("EJECT FAILED"), "check hood"); return; }
  lcdShow(F("REMOVE CUBE"), "LOAD: next cube");
}

// ---- 시리얼 명령 ----
void handleLine(char* s) {
  while (*s == ' ') s++;
  char* arg = s + 1;
  while (*arg == ' ') arg++;
  switch (toupper((unsigned char)s[0])) {            // 명령 글자는 대소문자 모두
    case 'S': doScramble(*arg ? strtoul(arg, nullptr, 10) : (micros() ^ millis())); break;
    case 'V': doSolve(); break;
    case 'M': {
      uint8_t seq[64];
      uint8_t n = parseSeq(arg, seq, sizeof(seq));
      if (!n) { Serial.println(F("ERR bad moves")); break; }
      mech.resetCounters();
      if (!execute(seq, n, F("MOVING"))) break;
      Serial.print(F("MOVED ")); Serial.print(n); printMechStats(); Serial.println();
      break;
    }
    case 'L': doLoad(); break;
    case 'E': doEject(); break;
    case 'F':
      if (mech.flip()) lcdShow(F("FLIPPED"), "x'"); break;
    case 'Y': {
      uint8_t k = (uint8_t)strtoul(arg, nullptr, 10); if (k < 1 || k > 3) k = 1;
      if (mech.spin(k)) lcdShow(F("SPIN"), k == 1 ? "y" : (k == 2 ? "y2" : "y'")); break;
    }
    case 'H': {
      char* e; long c = strtol(arg, &e, 10), o = strtol(e, &e, 10), l = strtol(e, &e, 10);
      if (c > 0) mech.hoodDeg[0] = c; if (o > 0) mech.hoodDeg[1] = o; if (l > 0) mech.hoodDeg[2] = l;
      Serial.print(F("HOOD DEG ")); Serial.print(mech.hoodDeg[0]); Serial.print(' '); Serial.print(mech.hoodDeg[1]); Serial.print(' '); Serial.println(mech.hoodDeg[2]);
      mech.rehood();
      break;
    }
    case 'K': mech.liftUpDeg = strtoul(arg, nullptr, 10); Serial.print(F("LIFT DEG ")); Serial.println(mech.liftUpDeg); break;
    case 'O': {
      char* e; mech.overshootSteps = min(strtoul(arg, &e, 10), 255UL);   // uint8_t 로 줄어들며 0 이 되지 않게
      while (*e == ' ') e++;
      if (*e) mech.playSteps = min(strtoul(e, nullptr, 10), 255UL);
      Serial.print(F("OVERSHOOT ")); Serial.print(mech.overshootSteps); Serial.print(F(" PLAY ")); Serial.println(mech.playSteps);
      break;
    }
    case 'J': {
      long n = constrain(strtol(arg, nullptr, 10), -800L, 800L);   // ±1 회전까지 (AVR int abs 넘침·R4 uint16_t 잘림 방지)
      motors.rotate(n < 0 ? -n : n, n > 0);
      Serial.print(F("JOG ")); Serial.println(n);
      break;
    }
    case 'P': printState(); break;
    case 'R': cube.reset(); Serial.println(F("RESET")); lcdShow(F("CUBE ROBOT"), "reset"); break;
    case 'Q': motors.setEnabled(*arg != '1'); Serial.print(F("MOTORS ")); Serial.println(motors.isEnabled() ? F("ON") : F("OFF")); break;
    case 0: break;
    default: Serial.println(F("ERR unknown command (S V M L E F Y P R Q H K O J)"));
  }
}

void pollSerial() {
  while (Serial.available()) {
    char ch = Serial.read();
    if (ch == '\n' || ch == '\r') {
      if (lineLen) { line[lineLen] = 0; handleLine(line); lineLen = 0; }
    } else if (lineLen < sizeof(line) - 1) line[lineLen++] = ch;
  }
}

// ---- 버튼 1개: millis 디바운스. 누른 채 1.2 s 가 지나면 LOAD (누른 동안 1회), 그 전에 떼면 START ----
enum BtnEvent : uint8_t { BTN_NONE = 0, BTN_START = 1, BTN_LOAD = 2 };
bool btnLast = false, btnStable = false, btnFired = false; unsigned long btnChange = 0, btnDown = 0;
uint8_t buttonEvent() {
  bool reading = digitalRead(BTN_PIN) == LOW;
  if (reading != btnLast) { btnChange = millis(); btnLast = reading; }
  if (millis() - btnChange >= DEBOUNCE_MS && reading != btnStable) {
    btnStable = reading;
    if (reading) { btnDown = millis(); btnFired = false; }
    else if (!btnFired) return BTN_START;                       // 짧게 눌렀다 뗌
  }
  if (btnStable && !btnFired && millis() - btnDown >= LONG_PRESS_MS) { btnFired = true; return BTN_LOAD; }
  return BTN_NONE;
}

void setup() {
  Serial.begin(115200);
  pinMode(BTN_PIN, INPUT_PULLUP);
  pinMode(BUZZER, OUTPUT);
  motors.begin();
  mech.begin(&motors);
  lcd.init();
  lcd.backlight();
  lcdShow(F("CUBE ROBOT V5"), "hold=LOAD tap=GO");
  Serial.println(F("READY cube-robot v5 (S [seed] | V | M <moves> | L | E | F | Y k | P | R | Q 0|1 | H | K | O | J)"));
}

void loop() {
  pollSerial();
  switch (buttonEvent()) {
    case BTN_LOAD: doLoad(); break;
    case BTN_START: if (cube.isSolved()) doScramble(micros() ^ millis()); else doSolve(); break;
    default: break;
  }
}
